v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
L 4 7040 -1090 7100 -1090 {}
L 4 7100 -1090 7100 -750 {}
L 4 7060 -750 7100 -750 {}
L 4 7040 -750 7060 -750 {}
L 4 7040 -1090 7040 -750 {}
L 4 7060 -1110 7060 -1090 {}
L 4 7070 -750 7070 -730 {}
L 4 7080 -1110 7080 -1090 {}
L 4 7020 -1030 7040 -1030 {}
L 4 7020 -1010 7040 -1010 {}
L 4 7020 -980 7040 -980 {}
L 4 7020 -960 7040 -960 {}
L 4 7020 -920 7040 -920 {}
L 4 7020 -880 7040 -880 {}
L 4 7020 -830 7040 -830 {}
L 4 7020 -810 7040 -810 {}
L 4 7020 -790 7040 -790 {}
L 4 7100 -1070 7120 -1070 {}
L 4 7020 -850 7040 -850 {}
L 4 7020 -900 7040 -900 {}
L 4 7020 -940 7040 -940 {}
L 4 8930 -1010 8930 -970 {}
L 4 8910 -1010 8950 -1010 {}
L 4 8850 -1010 8850 -970 {}
L 4 8830 -1010 8870 -1010 {}
L 4 8770 -1010 8770 -970 {}
L 4 8750 -1010 8790 -1010 {}
L 4 8690 -1010 8690 -970 {}
L 4 8670 -1010 8710 -1010 {}
L 4 8610 -1010 8610 -970 {}
L 4 8590 -1010 8630 -1010 {}
L 4 9070 -1010 9070 -970 {}
L 4 9050 -1010 9090 -1010 {}
L 4 8570 -970 9130 -970 {}
L 4 8965 -1015 8975 -1015 {}
L 4 8985 -1015 8995 -1015 {}
L 4 9005 -1015 9015 -1015 {}
L 4 9025 -1015 9035 -1015 {}
L 4 8590 -1020 8630 -1020 {}
L 4 8670 -1020 8710 -1020 {}
L 4 8750 -1020 8790 -1020 {}
L 4 8830 -1020 8870 -1020 {}
L 4 8910 -1020 8950 -1020 {}
L 4 9050 -1020 9090 -1020 {}
L 4 8930 -1060 8930 -1020 {}
L 4 8850 -1060 8850 -1020 {}
L 4 8770 -1060 8770 -1020 {}
L 4 8690 -1060 8690 -1020 {}
L 4 8610 -1060 8610 -1020 {}
L 4 9070 -1060 9070 -1020 {}
L 4 8930 -880 8930 -840 {}
L 4 8910 -880 8950 -880 {}
L 4 8850 -880 8850 -840 {}
L 4 8830 -880 8870 -880 {}
L 4 8770 -880 8770 -840 {}
L 4 8750 -880 8790 -880 {}
L 4 8690 -880 8690 -840 {}
L 4 8670 -880 8710 -880 {}
L 4 8610 -880 8610 -840 {}
L 4 8590 -880 8630 -880 {}
L 4 9070 -880 9070 -840 {}
L 4 9050 -880 9090 -880 {}
L 4 8570 -930 9130 -930 {}
L 4 8965 -885 8975 -885 {}
L 4 8985 -885 8995 -885 {}
L 4 9005 -885 9015 -885 {}
L 4 9025 -885 9035 -885 {}
L 4 8590 -890 8630 -890 {}
L 4 8670 -890 8710 -890 {}
L 4 8750 -890 8790 -890 {}
L 4 8830 -890 8870 -890 {}
L 4 8910 -890 8950 -890 {}
L 4 9050 -890 9090 -890 {}
L 4 8930 -930 8930 -890 {}
L 4 8850 -930 8850 -890 {}
L 4 8770 -930 8770 -890 {}
L 4 8690 -930 8690 -890 {}
L 4 8610 -930 8610 -890 {}
L 4 9070 -930 9070 -890 {}
L 4 8530 -930 8570 -930 {}
L 4 8530 -970 8570 -970 {}
L 4 8500 -970 8530 -980 {}
L 4 8500 -930 8530 -920 {}
L 4 8470 -930 8500 -930 {}
L 4 8470 -970 8500 -970 {}
L 4 8430 -970 8470 -970 {}
L 4 8430 -930 8470 -930 {}
L 4 9170 -990 9170 -910 {}
L 4 9170 -910 9250 -950 {}
L 4 9170 -990 9250 -950 {}
L 4 9130 -970 9170 -970 {}
L 4 9130 -930 9170 -930 {}
L 4 8600 -1070 8610 -1060 {}
L 4 8610 -1110 8610 -1080 {}
L 4 8680 -1070 8690 -1060 {}
L 4 8680 -1090 8680 -1080 {}
L 4 8690 -1110 8690 -1080 {}
L 4 8700 -1130 8700 -1080 {}
L 4 8760 -1070 8770 -1060 {}
L 4 8760 -1090 8760 -1080 {}
L 4 8770 -1110 8770 -1080 {}
L 4 8780 -1130 8780 -1080 {}
L 4 8840 -1070 8850 -1060 {}
L 4 8840 -1090 8840 -1080 {}
L 4 8850 -1110 8850 -1080 {}
L 4 8860 -1130 8860 -1080 {}
L 4 8920 -1070 8930 -1060 {}
L 4 8920 -1090 8920 -1080 {}
L 4 8930 -1110 8930 -1080 {}
L 4 8940 -1130 8940 -1080 {}
L 4 9060 -1070 9070 -1060 {}
L 4 9060 -1090 9060 -1080 {}
L 4 9070 -1110 9070 -1080 {}
L 4 9080 -1130 9080 -1080 {}
L 4 8570 -1090 9060 -1090 {}
L 4 8570 -1110 9070 -1110 {}
L 4 8570 -1130 9080 -1130 {}
L 4 8600 -830 8610 -840 {}
L 4 8610 -820 8610 -790 {}
L 4 8680 -830 8690 -840 {}
L 4 8680 -820 8680 -810 {}
L 4 8690 -820 8690 -790 {}
L 4 8700 -820 8700 -770 {}
L 4 8760 -830 8770 -840 {}
L 4 8760 -820 8760 -810 {}
L 4 8770 -820 8770 -790 {}
L 4 8780 -820 8780 -770 {}
L 4 8840 -830 8850 -840 {}
L 4 8840 -820 8840 -810 {}
L 4 8850 -820 8850 -790 {}
L 4 8860 -820 8860 -770 {}
L 4 8920 -830 8930 -840 {}
L 4 8920 -820 8920 -810 {}
L 4 8930 -820 8930 -790 {}
L 4 8940 -820 8940 -770 {}
L 4 9060 -830 9070 -840 {}
L 4 9060 -820 9060 -810 {}
L 4 9070 -820 9070 -790 {}
L 4 9080 -820 9080 -770 {}
L 4 8570 -810 9060 -810 {}
L 4 8570 -790 9070 -790 {}
L 4 8570 -770 9080 -770 {}
L 4 9250 -950 9320 -950 {}
L 4 8600 -1130 8600 -1080 {}
L 4 8600 -820 8600 -810 {}
T {Tie C0 to VDD - Enable C0 at P-input
Tie C0 to VSS - Disable C0 at N-input} 1360 -360 0 0 0.3 0.3 {}
T {127 Wafflecaps (13x10-1) for 7 Bit. 
3 Bin-Caps (4/8F, 2/8F and 1/8F) for 3 extra Bit.
+1 Unitcap.
--> 1023 unitcaps + 1 unitcap = 1024 unitcaps for 10 Bit
1024*0.45fF=0.4608pF} 7310 -860 0 0 0.6 0.6 {}
T {INP} 8360 -1000 0 0 0.6 0.6 {}
T {INN} 8360 -950 0 0 0.6 0.6 {}
T {+} 9170 -990 0 0 0.6 0.6 {}
T {-} 9170 -950 0 0 0.6 0.6 {}
T {C0} 8610 -1010 0 0 0.6 0.6 {}
T {C} 8690 -1010 0 0 0.6 0.6 {}
T {2C} 8770 -1010 0 0 0.6 0.6 {}
T {4C} 8850 -1010 0 0 0.6 0.6 {}
T {8C} 8930 -1010 0 0 0.6 0.6 {}
T {512C} 9070 -1010 0 0 0.6 0.6 {}
T {VDD} 8520 -1150 0 0 0.4 0.4 {}
T {vcm} 8520 -1130 0 0 0.4 0.4 {}
T {VSS} 8520 -1110 0 0 0.4 0.4 {}
T {VDD} 8520 -750 2 1 0.4 0.4 {}
T {vcm} 8520 -770 2 1 0.4 0.4 {}
T {VSS} 8520 -790 2 1 0.4 0.4 {}
T {C0} 8610 -930 0 0 0.6 0.6 {}
T {C} 8690 -930 0 0 0.6 0.6 {}
T {2C} 8770 -930 0 0 0.6 0.6 {}
T {4C} 8850 -930 0 0 0.6 0.6 {}
T {8C} 8930 -930 0 0 0.6 0.6 {}
T {1C+1023C thermometer-coded} 8640 -1170 0 0 0.4 0.4 {}
T {512C} 9070 -930 0 0 0.6 0.6 {}
T {extra} 8620 -1040 0 0 0.2 0.2 {}
T {bin1} 8700 -1040 0 0 0.2 0.2 {}
T {bin2} 8780 -1040 0 0 0.2 0.2 {}
T {bin4} 8860 -1040 0 0 0.2 0.2 {}
T {waffle8} 9080 -1040 0 0 0.2 0.2 {}
T {waffle8} 8940 -1040 0 0 0.2 0.2 {}
T {extra} 8620 -870 0 0 0.2 0.2 {}
T {bin1} 8700 -870 0 0 0.2 0.2 {}
T {bin2} 8780 -870 0 0 0.2 0.2 {}
T {bin4} 8860 -870 0 0 0.2 0.2 {}
T {waffle8} 9080 -870 0 0 0.2 0.2 {}
T {waffle8} 8940 -870 0 0 0.2 0.2 {}
N 690 -600 710 -600 {
lab=VDD}
N 690 -580 710 -580 {
lab=VSS}
N 690 -560 710 -560 {
lab=sample}
N 690 -540 710 -540 {
lab=sample_n}
N 690 -620 710 -620 {
lab=VDD}
N 750 -460 750 -450 {
lab=VSS}
N 830 -460 830 -450 {
lab=VDD}
N 850 -460 850 -450 {
lab=VSS}
N 1070 -460 1070 -450 {
lab=VSS}
N 1150 -460 1150 -440 {
lab=col_n[0]}
N 1170 -460 1170 -440 {
lab=col[0]}
N 1400 -460 1400 -450 {
lab=VSS}
N 1480 -460 1480 -440 {
lab=col_n[1]}
N 1430 -460 1430 -450 {
lab=en_C0_n}
N 1430 -450 1430 -440 {
lab=en_C0_n}
N 1500 -460 1500 -440 {
lab=col[1]}
N 750 -780 750 -770 {
lab=VSS}
N 750 -1080 750 -1070 {
lab=VSS}
N 1070 -1080 1070 -1070 {
lab=VSS}
N 1070 -780 1070 -770 {
lab=VSS}
N 1400 -780 1400 -770 {
lab=VSS}
N 1400 -1080 1400 -1070 {
lab=VSS}
N 1750 -1080 1750 -1070 {
lab=VSS}
N 1750 -780 1750 -770 {
lab=VSS}
N 2100 -780 2100 -770 {
lab=VSS}
N 2100 -1080 2100 -1070 {
lab=VSS}
N 2450 -1080 2450 -1070 {
lab=VSS}
N 2790 -1080 2790 -1070 {
lab=VSS}
N 2790 -780 2790 -770 {
lab=VSS}
N 2450 -780 2450 -770 {
lab=VSS}
N 3140 -1080 3140 -1070 {
lab=VSS}
N 3140 -780 3140 -770 {
lab=VSS}
N 3500 -1080 3500 -1070 {
lab=VSS}
N 3830 -1080 3830 -1070 {
lab=VSS}
N 3500 -780 3500 -770 {
lab=VSS}
N 3830 -780 3830 -770 {
lab=VSS}
N 4160 -780 4160 -770 {
lab=VSS}
N 4160 -1080 4160 -1070 {
lab=VSS}
N 4510 -1080 4510 -1070 {
lab=VSS}
N 4860 -1080 4860 -1070 {
lab=VSS}
N 4510 -780 4510 -770 {
lab=VSS}
N 4860 -780 4860 -770 {
lab=VSS}
N 5200 -1080 5200 -1070 {
lab=VSS}
N 5200 -780 5200 -770 {
lab=VSS}
N 5540 -1080 5540 -1070 {
lab=VSS}
N 5540 -780 5540 -770 {
lab=VSS}
N 2100 -460 2100 -450 {
lab=VSS}
N 2180 -460 2180 -440 {
lab=col_n[3]}
N 2200 -460 2200 -440 {
lab=col[3]}
N 1750 -460 1750 -450 {
lab=VSS}
N 1830 -460 1830 -440 {
lab=col_n[2]}
N 1850 -460 1850 -440 {
lab=col[2]}
N 2450 -460 2450 -450 {
lab=VSS}
N 2530 -460 2530 -440 {
lab=col_n[4]}
N 2550 -460 2550 -440 {
lab=col[4]}
N 2790 -460 2790 -450 {
lab=VSS}
N 2870 -460 2870 -440 {
lab=col_n[5]}
N 2890 -460 2890 -440 {
lab=col[5]}
N 3140 -460 3140 -450 {
lab=VSS}
N 3220 -460 3220 -440 {
lab=col_n[6]}
N 3170 -460 3170 -440 {
lab=en_bit_n[1]}
N 3240 -460 3240 -440 {
lab=col[6]}
N 3500 -460 3500 -450 {
lab=VSS}
N 3580 -460 3580 -440 {
lab=col_n[7]}
N 3530 -460 3530 -440 {
lab=en_bit_n[2]}
N 3600 -460 3600 -440 {
lab=col[7]}
N 3830 -460 3830 -450 {
lab=VSS}
N 3910 -460 3910 -440 {
lab=col_n[8]}
N 3860 -460 3860 -440 {
lab=en_bit_n[0]}
N 3930 -460 3930 -440 {
lab=col[8]}
N 4240 -460 4240 -440 {
lab=col_n[9]}
N 4260 -460 4260 -440 {
lab=col[9]}
N 4160 -460 4160 -450 {lab=VSS}
N 4590 -460 4590 -440 {
lab=col_n[10]}
N 4610 -460 4610 -440 {
lab=col[10]}
N 4510 -460 4510 -450 {lab=VSS}
N 4940 -460 4940 -440 {
lab=col_n[11]}
N 4960 -460 4960 -440 {
lab=col[11]}
N 4860 -460 4860 -450 {lab=VSS}
N 5280 -460 5280 -440 {
lab=col_n[12]}
N 5300 -460 5300 -440 {
lab=col[12]}
N 5200 -460 5200 -450 {lab=VSS}
N 5540 -460 5540 -450 {
lab=VSS}
N 5260 -460 5260 -440 {
lab=sw}
N 5340 -460 5340 -440 {
lab=sw_n}
N 5320 -460 5320 -440 {
lab=analog_in}
N 5620 -460 5620 -440 {
lab=VDD}
N 5640 -460 5640 -440 {
lab=VSS}
N 770 -700 770 -680 {
lab=vcm}
N 750 -690 750 -680 {
lab=VDD}
N 810 -700 810 -680 {
lab=ctop}
N 1090 -700 1090 -680 {
lab=vcm}
N 1070 -690 1070 -680 {
lab=VDD}
N 1130 -700 1130 -680 {
lab=ctop}
N 1420 -700 1420 -680 {
lab=vcm}
N 1400 -690 1400 -680 {
lab=VDD}
N 1460 -700 1460 -680 {
lab=ctop}
N 1770 -700 1770 -680 {
lab=vcm}
N 1750 -690 1750 -680 {
lab=VDD}
N 1810 -700 1810 -680 {
lab=ctop}
N 2120 -700 2120 -680 {
lab=vcm}
N 2100 -690 2100 -680 {
lab=VDD}
N 2160 -700 2160 -680 {
lab=ctop}
N 2470 -700 2470 -680 {
lab=vcm}
N 2450 -690 2450 -680 {
lab=VDD}
N 2510 -700 2510 -680 {
lab=ctop}
N 2810 -700 2810 -680 {
lab=vcm}
N 2790 -690 2790 -680 {
lab=VDD}
N 2850 -700 2850 -680 {
lab=ctop}
N 3160 -700 3160 -680 {
lab=vcm}
N 3140 -690 3140 -680 {
lab=VDD}
N 3200 -700 3200 -680 {
lab=ctop}
N 3520 -700 3520 -680 {
lab=vcm}
N 3500 -690 3500 -680 {
lab=VDD}
N 3560 -700 3560 -680 {
lab=ctop}
N 3850 -700 3850 -680 {
lab=vcm}
N 3830 -690 3830 -680 {
lab=VDD}
N 3890 -700 3890 -680 {
lab=ctop}
N 4180 -700 4180 -680 {
lab=vcm}
N 4160 -690 4160 -680 {
lab=VDD}
N 4220 -700 4220 -680 {
lab=ctop}
N 4530 -700 4530 -680 {
lab=vcm}
N 4510 -690 4510 -680 {
lab=VDD}
N 4570 -700 4570 -680 {
lab=ctop}
N 4880 -700 4880 -680 {
lab=vcm}
N 4860 -690 4860 -680 {
lab=VDD}
N 4920 -700 4920 -680 {
lab=ctop}
N 5220 -700 5220 -680 {
lab=vcm}
N 5200 -690 5200 -680 {
lab=VDD}
N 5260 -700 5260 -680 {
lab=ctop}
N 5560 -700 5560 -680 {
lab=vcm}
N 5540 -690 5540 -680 {
lab=VDD}
N 5600 -700 5600 -680 {
lab=ctop}
N 5560 -1020 5560 -1000 {
lab=vcm}
N 5540 -1010 5540 -1000 {
lab=VDD}
N 5600 -1020 5600 -1000 {
lab=ctop}
N 5560 -1320 5560 -1300 {
lab=vcm}
N 5540 -1310 5540 -1300 {
lab=VDD}
N 5600 -1320 5600 -1300 {
lab=ctop}
N 4880 -1320 4880 -1300 {
lab=vcm}
N 4860 -1310 4860 -1300 {
lab=VDD}
N 4920 -1320 4920 -1300 {
lab=ctop}
N 5220 -1320 5220 -1300 {
lab=vcm}
N 5200 -1310 5200 -1300 {
lab=VDD}
N 5260 -1320 5260 -1300 {
lab=ctop}
N 5220 -1020 5220 -1000 {
lab=vcm}
N 5200 -1010 5200 -1000 {
lab=VDD}
N 5260 -1020 5260 -1000 {
lab=ctop}
N 4880 -1020 4880 -1000 {
lab=vcm}
N 4860 -1010 4860 -1000 {
lab=VDD}
N 4920 -1020 4920 -1000 {
lab=ctop}
N 4530 -1020 4530 -1000 {
lab=vcm}
N 4510 -1010 4510 -1000 {
lab=VDD}
N 4570 -1020 4570 -1000 {
lab=ctop}
N 4530 -1320 4530 -1300 {
lab=vcm}
N 4510 -1310 4510 -1300 {
lab=VDD}
N 4570 -1320 4570 -1300 {
lab=ctop}
N 4180 -1320 4180 -1300 {
lab=vcm}
N 4160 -1310 4160 -1300 {
lab=VDD}
N 4220 -1320 4220 -1300 {
lab=ctop}
N 4180 -1020 4180 -1000 {
lab=vcm}
N 4160 -1010 4160 -1000 {
lab=VDD}
N 4220 -1020 4220 -1000 {
lab=ctop}
N 3850 -1020 3850 -1000 {
lab=vcm}
N 3830 -1010 3830 -1000 {
lab=VDD}
N 3890 -1020 3890 -1000 {
lab=ctop}
N 3850 -1320 3850 -1300 {
lab=vcm}
N 3830 -1310 3830 -1300 {
lab=VDD}
N 3890 -1320 3890 -1300 {
lab=ctop}
N 3520 -1320 3520 -1300 {
lab=vcm}
N 3500 -1310 3500 -1300 {
lab=VDD}
N 3560 -1320 3560 -1300 {
lab=ctop}
N 3520 -1020 3520 -1000 {
lab=vcm}
N 3500 -1010 3500 -1000 {
lab=VDD}
N 3560 -1020 3560 -1000 {
lab=ctop}
N 3160 -1020 3160 -1000 {
lab=vcm}
N 3140 -1010 3140 -1000 {
lab=VDD}
N 3200 -1020 3200 -1000 {
lab=ctop}
N 3160 -1320 3160 -1300 {
lab=vcm}
N 3140 -1310 3140 -1300 {
lab=VDD}
N 3200 -1320 3200 -1300 {
lab=ctop}
N 2810 -1320 2810 -1300 {
lab=vcm}
N 2790 -1310 2790 -1300 {
lab=VDD}
N 2850 -1320 2850 -1300 {
lab=ctop}
N 2810 -1020 2810 -1000 {
lab=vcm}
N 2790 -1010 2790 -1000 {
lab=VDD}
N 2850 -1020 2850 -1000 {
lab=ctop}
N 2470 -1020 2470 -1000 {
lab=vcm}
N 2450 -1010 2450 -1000 {
lab=VDD}
N 2510 -1020 2510 -1000 {
lab=ctop}
N 2470 -1320 2470 -1300 {
lab=vcm}
N 2450 -1310 2450 -1300 {
lab=VDD}
N 2510 -1320 2510 -1300 {
lab=ctop}
N 2120 -1320 2120 -1300 {
lab=vcm}
N 2100 -1310 2100 -1300 {
lab=VDD}
N 2160 -1320 2160 -1300 {
lab=ctop}
N 2120 -1020 2120 -1000 {
lab=vcm}
N 2100 -1010 2100 -1000 {
lab=VDD}
N 2160 -1020 2160 -1000 {
lab=ctop}
N 1770 -1020 1770 -1000 {
lab=vcm}
N 1750 -1010 1750 -1000 {
lab=VDD}
N 1810 -1020 1810 -1000 {
lab=ctop}
N 1770 -1320 1770 -1300 {
lab=vcm}
N 1750 -1310 1750 -1300 {
lab=VDD}
N 1810 -1320 1810 -1300 {
lab=ctop}
N 1420 -1320 1420 -1300 {
lab=vcm}
N 1400 -1310 1400 -1300 {
lab=VDD}
N 1460 -1320 1460 -1300 {
lab=ctop}
N 1090 -1320 1090 -1300 {
lab=vcm}
N 1070 -1310 1070 -1300 {
lab=VDD}
N 1130 -1320 1130 -1300 {
lab=ctop}
N 1090 -1020 1090 -1000 {
lab=vcm}
N 1070 -1010 1070 -1000 {
lab=VDD}
N 1130 -1020 1130 -1000 {
lab=ctop}
N 1420 -1020 1420 -1000 {
lab=vcm}
N 1400 -1010 1400 -1000 {
lab=VDD}
N 1460 -1020 1460 -1000 {
lab=ctop}
N 770 -1320 770 -1300 {
lab=vcm}
N 750 -1310 750 -1300 {
lab=VDD}
N 810 -1320 810 -1300 {
lab=ctop}
N 770 -1020 770 -1000 {
lab=vcm}
N 750 -1010 750 -1000 {
lab=VDD}
N 810 -1020 810 -1000 {
lab=ctop}
N 690 -860 710 -860 {
lab=sample_n}
N 690 -880 710 -880 {
lab=sample}
N 690 -900 710 -900 {
lab=rowon_n[0]}
N 690 -920 710 -920 {
lab=row_n[0]}
N 690 -940 710 -940 {
lab=rowoff_n[0]}
N 690 -1160 710 -1160 {
lab=sample_n}
N 690 -1180 710 -1180 {
lab=sample}
N 690 -1200 710 -1200 {
lab=rowon_n[1]}
N 690 -1220 710 -1220 {
lab=row_n[1]}
N 690 -1240 710 -1240 {
lab=rowoff_n[1]}
N 930 -1180 1030 -1180 {lab=#net1}
N 930 -1160 1030 -1160 {lab=#net2}
N 710 -1240 720 -1250 {lab=rowoff_n[1]}
N 720 -1250 940 -1250 {lab=rowoff_n[1]}
N 940 -1250 950 -1240 {lab=rowoff_n[1]}
N 950 -1240 1030 -1240 {lab=rowoff_n[1]}
N 710 -1220 720 -1230 {lab=row_n[1]}
N 720 -1230 940 -1230 {lab=row_n[1]}
N 940 -1230 950 -1220 {lab=row_n[1]}
N 950 -1220 1030 -1220 {lab=row_n[1]}
N 710 -1200 720 -1210 {lab=rowon_n[1]}
N 720 -1210 940 -1210 {lab=rowon_n[1]}
N 940 -1210 950 -1200 {lab=rowon_n[1]}
N 950 -1200 1030 -1200 {lab=rowon_n[1]}
N 1030 -1240 1040 -1250 {lab=rowoff_n[1]}
N 1030 -1220 1040 -1230 {lab=row_n[1]}
N 1040 -1230 1240 -1230 {lab=row_n[1]}
N 1240 -1230 1250 -1220 {lab=row_n[1]}
N 1250 -1220 1360 -1220 {lab=row_n[1]}
N 1040 -1250 1240 -1250 {lab=rowoff_n[1]}
N 1240 -1250 1250 -1240 {lab=rowoff_n[1]}
N 1250 -1240 1360 -1240 {lab=rowoff_n[1]}
N 1030 -1200 1040 -1210 {lab=rowon_n[1]}
N 1040 -1210 1240 -1210 {lab=rowon_n[1]}
N 1240 -1210 1250 -1200 {lab=rowon_n[1]}
N 1250 -1200 1360 -1200 {lab=rowon_n[1]}
N 1030 -1180 1040 -1190 {lab=#net1}
N 1040 -1190 1240 -1190 {lab=#net1}
N 1240 -1190 1250 -1180 {lab=#net1}
N 1250 -1180 1360 -1180 {lab=#net1}
N 1030 -1160 1040 -1170 {lab=#net2}
N 1040 -1170 1240 -1170 {lab=#net2}
N 1240 -1170 1250 -1160 {lab=#net2}
N 1250 -1160 1360 -1160 {lab=#net2}
N 1360 -1220 1370 -1230 {lab=row_n[1]}
N 1370 -1230 1570 -1230 {lab=row_n[1]}
N 1570 -1230 1580 -1220 {lab=row_n[1]}
N 1580 -1220 1710 -1220 {lab=row_n[1]}
N 1360 -1200 1370 -1210 {lab=rowon_n[1]}
N 1370 -1210 1570 -1210 {lab=rowon_n[1]}
N 1570 -1210 1580 -1200 {lab=rowon_n[1]}
N 1580 -1200 1710 -1200 {lab=rowon_n[1]}
N 1360 -1180 1370 -1190 {lab=#net1}
N 1370 -1190 1570 -1190 {lab=#net1}
N 1570 -1190 1580 -1180 {lab=#net1}
N 1580 -1180 1710 -1180 {lab=#net1}
N 1360 -1160 1380 -1170 {lab=#net2}
N 1380 -1170 1570 -1170 {lab=#net2}
N 1570 -1170 1580 -1160 {lab=#net2}
N 1580 -1160 1710 -1160 {lab=#net2}
N 1360 -1240 1370 -1250 {lab=rowoff_n[1]}
N 1370 -1250 1570 -1250 {lab=rowoff_n[1]}
N 1570 -1250 1580 -1240 {lab=rowoff_n[1]}
N 1580 -1240 1710 -1240 {lab=rowoff_n[1]}
N 1710 -1240 1720 -1250 {lab=rowoff_n[1]}
N 1720 -1250 1920 -1250 {lab=rowoff_n[1]}
N 1920 -1250 1930 -1240 {lab=rowoff_n[1]}
N 1930 -1240 2060 -1240 {lab=rowoff_n[1]}
N 1710 -1220 1720 -1230 {lab=row_n[1]}
N 1720 -1230 1920 -1230 {lab=row_n[1]}
N 1920 -1230 1930 -1220 {lab=row_n[1]}
N 1930 -1220 2060 -1220 {lab=row_n[1]}
N 1710 -1200 1720 -1210 {lab=rowon_n[1]}
N 1720 -1210 1920 -1210 {lab=rowon_n[1]}
N 1920 -1210 1930 -1200 {lab=rowon_n[1]}
N 1930 -1200 2060 -1200 {lab=rowon_n[1]}
N 1710 -1180 1720 -1190 {lab=#net1}
N 1720 -1190 1920 -1190 {lab=#net1}
N 1920 -1190 1930 -1180 {lab=#net1}
N 1930 -1180 2060 -1180 {lab=#net1}
N 1710 -1160 1720 -1170 {lab=#net2}
N 1720 -1170 1920 -1170 {lab=#net2}
N 1920 -1170 1930 -1160 {lab=#net2}
N 1930 -1160 2060 -1160 {lab=#net2}
N 2060 -1240 2070 -1250 {lab=rowoff_n[1]}
N 2070 -1250 2270 -1250 {lab=rowoff_n[1]}
N 2270 -1250 2280 -1240 {lab=rowoff_n[1]}
N 2280 -1240 2410 -1240 {lab=rowoff_n[1]}
N 2060 -1220 2070 -1230 {lab=row_n[1]}
N 2070 -1230 2270 -1230 {lab=row_n[1]}
N 2270 -1230 2280 -1220 {lab=row_n[1]}
N 2280 -1220 2410 -1220 {lab=row_n[1]}
N 2060 -1200 2070 -1210 {lab=rowon_n[1]}
N 2070 -1210 2270 -1210 {lab=rowon_n[1]}
N 2270 -1210 2280 -1200 {lab=rowon_n[1]}
N 2280 -1200 2410 -1200 {lab=rowon_n[1]}
N 2270 -1190 2280 -1180 {lab=#net1}
N 2280 -1180 2410 -1180 {lab=#net1}
N 2060 -1160 2070 -1170 {lab=#net2}
N 2070 -1170 2270 -1170 {lab=#net2}
N 2270 -1170 2280 -1160 {lab=#net2}
N 2280 -1160 2410 -1160 {lab=#net2}
N 2060 -1180 2070 -1190 {lab=#net1}
N 2070 -1190 2270 -1190 {lab=#net1}
N 2410 -1240 2420 -1250 {lab=rowoff_n[1]}
N 2420 -1250 2620 -1250 {lab=rowoff_n[1]}
N 2620 -1250 2630 -1240 {lab=rowoff_n[1]}
N 2630 -1240 2750 -1240 {lab=rowoff_n[1]}
N 2410 -1220 2420 -1230 {lab=row_n[1]}
N 2420 -1230 2620 -1230 {lab=row_n[1]}
N 2620 -1230 2630 -1220 {lab=row_n[1]}
N 2630 -1220 2750 -1220 {lab=row_n[1]}
N 2410 -1200 2420 -1210 {lab=rowon_n[1]}
N 2420 -1210 2620 -1210 {lab=rowon_n[1]}
N 2620 -1210 2630 -1200 {lab=rowon_n[1]}
N 2630 -1200 2750 -1200 {lab=rowon_n[1]}
N 2410 -1180 2420 -1190 {lab=#net1}
N 2420 -1190 2620 -1190 {lab=#net1}
N 2620 -1190 2630 -1180 {lab=#net1}
N 2630 -1180 2750 -1180 {lab=#net1}
N 2410 -1160 2420 -1170 {lab=#net2}
N 2420 -1170 2620 -1170 {lab=#net2}
N 2620 -1170 2630 -1160 {lab=#net2}
N 2630 -1160 2750 -1160 {lab=#net2}
N 2750 -1240 2760 -1250 {lab=rowoff_n[1]}
N 2760 -1250 2960 -1250 {lab=rowoff_n[1]}
N 2960 -1250 2970 -1240 {lab=rowoff_n[1]}
N 2970 -1240 3100 -1240 {lab=rowoff_n[1]}
N 2750 -1220 2760 -1230 {lab=row_n[1]}
N 2760 -1230 2960 -1230 {lab=row_n[1]}
N 2960 -1230 2970 -1220 {lab=row_n[1]}
N 2970 -1220 3100 -1220 {lab=row_n[1]}
N 2750 -1200 2760 -1210 {lab=rowon_n[1]}
N 2760 -1210 2960 -1210 {lab=rowon_n[1]}
N 2960 -1210 2970 -1200 {lab=rowon_n[1]}
N 2970 -1200 3100 -1200 {lab=rowon_n[1]}
N 2750 -1180 2760 -1190 {lab=#net1}
N 2760 -1190 2960 -1190 {lab=#net1}
N 2750 -1160 2760 -1170 {lab=#net2}
N 2760 -1170 2960 -1170 {lab=#net2}
N 2960 -1170 2970 -1160 {lab=#net2}
N 2970 -1160 3100 -1160 {lab=#net2}
N 2960 -1190 2970 -1180 {lab=#net1}
N 2970 -1180 3100 -1180 {lab=#net1}
N 3100 -1240 3110 -1250 {lab=rowoff_n[1]}
N 3110 -1250 3310 -1250 {lab=rowoff_n[1]}
N 3310 -1250 3320 -1240 {lab=rowoff_n[1]}
N 3320 -1240 3460 -1240 {lab=rowoff_n[1]}
N 3100 -1220 3110 -1230 {lab=row_n[1]}
N 3110 -1230 3310 -1230 {lab=row_n[1]}
N 3310 -1230 3320 -1220 {lab=row_n[1]}
N 3320 -1220 3460 -1220 {lab=row_n[1]}
N 3100 -1200 3110 -1210 {lab=rowon_n[1]}
N 3110 -1210 3310 -1210 {lab=rowon_n[1]}
N 3310 -1210 3320 -1200 {lab=rowon_n[1]}
N 3320 -1200 3460 -1200 {lab=rowon_n[1]}
N 3100 -1180 3110 -1190 {lab=#net1}
N 3110 -1190 3310 -1190 {lab=#net1}
N 3310 -1190 3320 -1180 {lab=#net1}
N 3320 -1180 3460 -1180 {lab=#net1}
N 3100 -1160 3110 -1170 {lab=#net2}
N 3110 -1170 3310 -1170 {lab=#net2}
N 3310 -1170 3320 -1160 {lab=#net2}
N 3320 -1160 3460 -1160 {lab=#net2}
N 3460 -1240 3470 -1250 {lab=rowoff_n[1]}
N 3470 -1250 3670 -1250 {lab=rowoff_n[1]}
N 3670 -1250 3680 -1240 {lab=rowoff_n[1]}
N 3680 -1240 3790 -1240 {lab=rowoff_n[1]}
N 3460 -1220 3470 -1230 {lab=row_n[1]}
N 3470 -1230 3670 -1230 {lab=row_n[1]}
N 3670 -1230 3680 -1220 {lab=row_n[1]}
N 3680 -1220 3790 -1220 {lab=row_n[1]}
N 3460 -1200 3470 -1210 {lab=rowon_n[1]}
N 3470 -1210 3670 -1210 {lab=rowon_n[1]}
N 3670 -1210 3680 -1200 {lab=rowon_n[1]}
N 3680 -1200 3790 -1200 {lab=rowon_n[1]}
N 3460 -1180 3470 -1190 {lab=#net1}
N 3470 -1190 3670 -1190 {lab=#net1}
N 3670 -1190 3680 -1180 {lab=#net1}
N 3680 -1180 3790 -1180 {lab=#net1}
N 3460 -1160 3470 -1170 {lab=#net2}
N 3470 -1170 3670 -1170 {lab=#net2}
N 3670 -1170 3680 -1160 {lab=#net2}
N 3680 -1160 3790 -1160 {lab=#net2}
N 3790 -1240 3800 -1250 {lab=rowoff_n[1]}
N 3800 -1250 4000 -1250 {lab=rowoff_n[1]}
N 4000 -1250 4010 -1240 {lab=rowoff_n[1]}
N 4010 -1240 4120 -1240 {lab=rowoff_n[1]}
N 3790 -1220 3800 -1230 {lab=row_n[1]}
N 3800 -1230 4000 -1230 {lab=row_n[1]}
N 4000 -1230 4010 -1220 {lab=row_n[1]}
N 4010 -1220 4120 -1220 {lab=row_n[1]}
N 3790 -1200 3800 -1210 {lab=rowon_n[1]}
N 3800 -1210 4000 -1210 {lab=rowon_n[1]}
N 4000 -1210 4010 -1200 {lab=rowon_n[1]}
N 4010 -1200 4120 -1200 {lab=rowon_n[1]}
N 3790 -1180 3800 -1190 {lab=#net1}
N 3800 -1190 4000 -1190 {lab=#net1}
N 4000 -1190 4010 -1180 {lab=#net1}
N 4010 -1180 4120 -1180 {lab=#net1}
N 3790 -1160 3800 -1170 {lab=#net2}
N 3800 -1170 4000 -1170 {lab=#net2}
N 4000 -1170 4020 -1160 {lab=#net2}
N 4020 -1160 4120 -1160 {lab=#net2}
N 4120 -1240 4130 -1250 {lab=rowoff_n[1]}
N 4130 -1250 4330 -1250 {lab=rowoff_n[1]}
N 4330 -1250 4340 -1240 {lab=rowoff_n[1]}
N 4340 -1240 4470 -1240 {lab=rowoff_n[1]}
N 4120 -1220 4130 -1230 {lab=row_n[1]}
N 4130 -1230 4330 -1230 {lab=row_n[1]}
N 4330 -1230 4340 -1220 {lab=row_n[1]}
N 4340 -1220 4470 -1220 {lab=row_n[1]}
N 4120 -1200 4130 -1210 {lab=rowon_n[1]}
N 4130 -1210 4330 -1210 {lab=rowon_n[1]}
N 4330 -1210 4340 -1200 {lab=rowon_n[1]}
N 4340 -1200 4470 -1200 {lab=rowon_n[1]}
N 4120 -1180 4130 -1190 {lab=#net1}
N 4130 -1190 4330 -1190 {lab=#net1}
N 4330 -1190 4340 -1180 {lab=#net1}
N 4340 -1180 4470 -1180 {lab=#net1}
N 4120 -1160 4130 -1170 {lab=#net2}
N 4130 -1170 4330 -1170 {lab=#net2}
N 4330 -1170 4340 -1160 {lab=#net2}
N 4340 -1160 4470 -1160 {lab=#net2}
N 4470 -1240 4480 -1250 {lab=rowoff_n[1]}
N 4480 -1250 4680 -1250 {lab=rowoff_n[1]}
N 4680 -1250 4690 -1240 {lab=rowoff_n[1]}
N 4690 -1240 4820 -1240 {lab=rowoff_n[1]}
N 4470 -1220 4480 -1230 {lab=row_n[1]}
N 4480 -1230 4680 -1230 {lab=row_n[1]}
N 4470 -1200 4480 -1210 {lab=rowon_n[1]}
N 4480 -1210 4680 -1210 {lab=rowon_n[1]}
N 4680 -1210 4690 -1200 {lab=rowon_n[1]}
N 4690 -1200 4820 -1200 {lab=rowon_n[1]}
N 4680 -1230 4690 -1220 {lab=row_n[1]}
N 4690 -1220 4820 -1220 {lab=row_n[1]}
N 4470 -1180 4480 -1190 {lab=#net1}
N 4480 -1190 4680 -1190 {lab=#net1}
N 4680 -1190 4690 -1180 {lab=#net1}
N 4690 -1180 4820 -1180 {lab=#net1}
N 4470 -1160 4480 -1170 {lab=#net2}
N 4480 -1170 4680 -1170 {lab=#net2}
N 4680 -1170 4690 -1160 {lab=#net2}
N 4690 -1160 4820 -1160 {lab=#net2}
N 4820 -1240 4830 -1250 {lab=rowoff_n[1]}
N 4830 -1250 5030 -1250 {lab=rowoff_n[1]}
N 5030 -1250 5040 -1240 {lab=rowoff_n[1]}
N 5040 -1240 5160 -1240 {lab=rowoff_n[1]}
N 4820 -1220 4830 -1230 {lab=row_n[1]}
N 4830 -1230 5030 -1230 {lab=row_n[1]}
N 5030 -1230 5040 -1220 {lab=row_n[1]}
N 5040 -1220 5160 -1220 {lab=row_n[1]}
N 4820 -1200 4830 -1210 {lab=rowon_n[1]}
N 4830 -1210 5030 -1210 {lab=rowon_n[1]}
N 5030 -1210 5040 -1200 {lab=rowon_n[1]}
N 5040 -1200 5160 -1200 {lab=rowon_n[1]}
N 4820 -1180 4830 -1190 {lab=#net1}
N 4830 -1190 5030 -1190 {lab=#net1}
N 5030 -1190 5040 -1180 {lab=#net1}
N 5040 -1180 5160 -1180 {lab=#net1}
N 4820 -1160 4830 -1170 {lab=#net2}
N 4830 -1170 5030 -1170 {lab=#net2}
N 5030 -1170 5040 -1160 {lab=#net2}
N 5040 -1160 5160 -1160 {lab=#net2}
N 5160 -1240 5170 -1250 {lab=rowoff_n[1]}
N 5170 -1250 5370 -1250 {lab=rowoff_n[1]}
N 5370 -1250 5380 -1240 {lab=rowoff_n[1]}
N 5380 -1240 5500 -1240 {lab=rowoff_n[1]}
N 5160 -1220 5170 -1230 {lab=row_n[1]}
N 5170 -1230 5370 -1230 {lab=row_n[1]}
N 5370 -1230 5380 -1220 {lab=row_n[1]}
N 5380 -1220 5500 -1220 {lab=row_n[1]}
N 5160 -1200 5170 -1210 {lab=rowon_n[1]}
N 5170 -1210 5370 -1210 {lab=rowon_n[1]}
N 5370 -1210 5380 -1200 {lab=rowon_n[1]}
N 5380 -1200 5500 -1200 {lab=rowon_n[1]}
N 5160 -1180 5170 -1190 {lab=#net1}
N 5170 -1190 5370 -1190 {lab=#net1}
N 5370 -1190 5380 -1180 {lab=#net1}
N 5380 -1180 5500 -1180 {lab=#net1}
N 5160 -1160 5170 -1170 {lab=#net2}
N 5170 -1170 5370 -1170 {lab=#net2}
N 5370 -1170 5390 -1160 {lab=#net2}
N 5390 -1160 5500 -1160 {lab=#net2}
N 5500 -1240 5510 -1250 {lab=rowoff_n[1]}
N 5510 -1250 5710 -1250 {lab=rowoff_n[1]}
N 5500 -1220 5510 -1230 {lab=row_n[1]}
N 5510 -1230 5710 -1230 {lab=row_n[1]}
N 5710 -1230 5720 -1220 {lab=row_n[1]}
N 5710 -1250 5720 -1240 {lab=rowoff_n[1]}
N 5500 -1200 5510 -1210 {lab=rowon_n[1]}
N 5510 -1210 5710 -1210 {lab=rowon_n[1]}
N 5500 -1180 5510 -1190 {lab=#net1}
N 5510 -1190 5710 -1190 {lab=#net1}
N 5710 -1190 5720 -1180 {lab=#net1}
N 5500 -1160 5510 -1170 {lab=#net2}
N 5510 -1170 5710 -1170 {lab=#net2}
N 5710 -1170 5720 -1160 {lab=#net2}
N 5710 -1210 5720 -1200 {lab=rowon_n[1]}
N 750 -1410 750 -1400 {
lab=VSS}
N 1070 -1410 1070 -1400 {
lab=VSS}
N 1400 -1410 1400 -1400 {
lab=VSS}
N 1750 -1410 1750 -1400 {
lab=VSS}
N 2100 -1410 2100 -1400 {
lab=VSS}
N 2450 -1410 2450 -1400 {
lab=VSS}
N 2790 -1410 2790 -1400 {
lab=VSS}
N 3140 -1410 3140 -1400 {
lab=VSS}
N 3500 -1410 3500 -1400 {
lab=VSS}
N 3830 -1410 3830 -1400 {
lab=VSS}
N 4160 -1410 4160 -1400 {
lab=VSS}
N 4510 -1410 4510 -1400 {
lab=VSS}
N 4860 -1410 4860 -1400 {
lab=VSS}
N 5200 -1410 5200 -1400 {
lab=VSS}
N 5540 -1410 5540 -1400 {
lab=VSS}
N 5560 -1650 5560 -1630 {
lab=vcm}
N 5540 -1640 5540 -1630 {
lab=VDD}
N 5600 -1650 5600 -1630 {
lab=ctop}
N 4880 -1650 4880 -1630 {
lab=vcm}
N 4860 -1640 4860 -1630 {
lab=VDD}
N 4920 -1650 4920 -1630 {
lab=ctop}
N 5220 -1650 5220 -1630 {
lab=vcm}
N 5200 -1640 5200 -1630 {
lab=VDD}
N 5260 -1650 5260 -1630 {
lab=ctop}
N 4530 -1650 4530 -1630 {
lab=vcm}
N 4510 -1640 4510 -1630 {
lab=VDD}
N 4570 -1650 4570 -1630 {
lab=ctop}
N 4180 -1650 4180 -1630 {
lab=vcm}
N 4160 -1640 4160 -1630 {
lab=VDD}
N 4220 -1650 4220 -1630 {
lab=ctop}
N 3850 -1650 3850 -1630 {
lab=vcm}
N 3830 -1640 3830 -1630 {
lab=VDD}
N 3890 -1650 3890 -1630 {
lab=ctop}
N 3520 -1650 3520 -1630 {
lab=vcm}
N 3500 -1640 3500 -1630 {
lab=VDD}
N 3560 -1650 3560 -1630 {
lab=ctop}
N 3160 -1650 3160 -1630 {
lab=vcm}
N 3140 -1640 3140 -1630 {
lab=VDD}
N 3200 -1650 3200 -1630 {
lab=ctop}
N 2810 -1650 2810 -1630 {
lab=vcm}
N 2790 -1640 2790 -1630 {
lab=VDD}
N 2850 -1650 2850 -1630 {
lab=ctop}
N 2470 -1650 2470 -1630 {
lab=vcm}
N 2450 -1640 2450 -1630 {
lab=VDD}
N 2510 -1650 2510 -1630 {
lab=ctop}
N 2120 -1650 2120 -1630 {
lab=vcm}
N 2100 -1640 2100 -1630 {
lab=VDD}
N 2160 -1650 2160 -1630 {
lab=ctop}
N 1770 -1650 1770 -1630 {
lab=vcm}
N 1750 -1640 1750 -1630 {
lab=VDD}
N 1810 -1650 1810 -1630 {
lab=ctop}
N 1420 -1650 1420 -1630 {
lab=vcm}
N 1400 -1640 1400 -1630 {
lab=VDD}
N 1460 -1650 1460 -1630 {
lab=ctop}
N 1090 -1650 1090 -1630 {
lab=vcm}
N 1070 -1640 1070 -1630 {
lab=VDD}
N 1130 -1650 1130 -1630 {
lab=ctop}
N 770 -1650 770 -1630 {
lab=vcm}
N 750 -1640 750 -1630 {
lab=VDD}
N 810 -1650 810 -1630 {
lab=ctop}
N 690 -1490 710 -1490 {
lab=sample_n}
N 690 -1510 710 -1510 {
lab=sample}
N 690 -1530 710 -1530 {
lab=rowon_n[2]}
N 690 -1550 710 -1550 {
lab=row_n[2]}
N 690 -1570 710 -1570 {
lab=rowoff_n[2]}
N 930 -1510 1030 -1510 {lab=#net3}
N 930 -1490 1030 -1490 {lab=#net4}
N 710 -1570 720 -1580 {lab=rowoff_n[2]}
N 720 -1580 940 -1580 {lab=rowoff_n[2]}
N 940 -1580 950 -1570 {lab=rowoff_n[2]}
N 950 -1570 1030 -1570 {lab=rowoff_n[2]}
N 710 -1550 720 -1560 {lab=row_n[2]}
N 720 -1560 940 -1560 {lab=row_n[2]}
N 940 -1560 950 -1550 {lab=row_n[2]}
N 950 -1550 1030 -1550 {lab=row_n[2]}
N 710 -1530 720 -1540 {lab=rowon_n[2]}
N 720 -1540 940 -1540 {lab=rowon_n[2]}
N 940 -1540 950 -1530 {lab=rowon_n[2]}
N 950 -1530 1030 -1530 {lab=rowon_n[2]}
N 1030 -1570 1040 -1580 {lab=rowoff_n[2]}
N 1030 -1550 1040 -1560 {lab=row_n[2]}
N 1040 -1560 1240 -1560 {lab=row_n[2]}
N 1240 -1560 1250 -1550 {lab=row_n[2]}
N 1250 -1550 1360 -1550 {lab=row_n[2]}
N 1040 -1580 1240 -1580 {lab=rowoff_n[2]}
N 1240 -1580 1250 -1570 {lab=rowoff_n[2]}
N 1250 -1570 1360 -1570 {lab=rowoff_n[2]}
N 1030 -1530 1040 -1540 {lab=rowon_n[2]}
N 1040 -1540 1240 -1540 {lab=rowon_n[2]}
N 1240 -1540 1250 -1530 {lab=rowon_n[2]}
N 1250 -1530 1360 -1530 {lab=rowon_n[2]}
N 1030 -1510 1040 -1520 {lab=#net3}
N 1040 -1520 1240 -1520 {lab=#net3}
N 1240 -1520 1250 -1510 {lab=#net3}
N 1250 -1510 1360 -1510 {lab=#net3}
N 1030 -1490 1040 -1500 {lab=#net4}
N 1040 -1500 1240 -1500 {lab=#net4}
N 1240 -1500 1250 -1490 {lab=#net4}
N 1250 -1490 1360 -1490 {lab=#net4}
N 1360 -1550 1370 -1560 {lab=row_n[2]}
N 1370 -1560 1570 -1560 {lab=row_n[2]}
N 1570 -1560 1580 -1550 {lab=row_n[2]}
N 1580 -1550 1710 -1550 {lab=row_n[2]}
N 1360 -1530 1370 -1540 {lab=rowon_n[2]}
N 1370 -1540 1570 -1540 {lab=rowon_n[2]}
N 1570 -1540 1580 -1530 {lab=rowon_n[2]}
N 1580 -1530 1710 -1530 {lab=rowon_n[2]}
N 1360 -1510 1370 -1520 {lab=#net3}
N 1370 -1520 1570 -1520 {lab=#net3}
N 1570 -1520 1580 -1510 {lab=#net3}
N 1580 -1510 1710 -1510 {lab=#net3}
N 1360 -1490 1380 -1500 {lab=#net4}
N 1380 -1500 1570 -1500 {lab=#net4}
N 1570 -1500 1580 -1490 {lab=#net4}
N 1580 -1490 1710 -1490 {lab=#net4}
N 1360 -1570 1370 -1580 {lab=rowoff_n[2]}
N 1370 -1580 1570 -1580 {lab=rowoff_n[2]}
N 1570 -1580 1580 -1570 {lab=rowoff_n[2]}
N 1580 -1570 1710 -1570 {lab=rowoff_n[2]}
N 1710 -1570 1720 -1580 {lab=rowoff_n[2]}
N 1720 -1580 1920 -1580 {lab=rowoff_n[2]}
N 1920 -1580 1930 -1570 {lab=rowoff_n[2]}
N 1930 -1570 2060 -1570 {lab=rowoff_n[2]}
N 1710 -1550 1720 -1560 {lab=row_n[2]}
N 1720 -1560 1920 -1560 {lab=row_n[2]}
N 1920 -1560 1930 -1550 {lab=row_n[2]}
N 1930 -1550 2060 -1550 {lab=row_n[2]}
N 1710 -1530 1720 -1540 {lab=rowon_n[2]}
N 1720 -1540 1920 -1540 {lab=rowon_n[2]}
N 1920 -1540 1930 -1530 {lab=rowon_n[2]}
N 1930 -1530 2060 -1530 {lab=rowon_n[2]}
N 1710 -1510 1720 -1520 {lab=#net3}
N 1720 -1520 1920 -1520 {lab=#net3}
N 1920 -1520 1930 -1510 {lab=#net3}
N 1930 -1510 2060 -1510 {lab=#net3}
N 1710 -1490 1720 -1500 {lab=#net4}
N 1720 -1500 1920 -1500 {lab=#net4}
N 1920 -1500 1930 -1490 {lab=#net4}
N 1930 -1490 2060 -1490 {lab=#net4}
N 2060 -1570 2070 -1580 {lab=rowoff_n[2]}
N 2070 -1580 2270 -1580 {lab=rowoff_n[2]}
N 2270 -1580 2280 -1570 {lab=rowoff_n[2]}
N 2280 -1570 2410 -1570 {lab=rowoff_n[2]}
N 2060 -1550 2070 -1560 {lab=row_n[2]}
N 2070 -1560 2270 -1560 {lab=row_n[2]}
N 2270 -1560 2280 -1550 {lab=row_n[2]}
N 2280 -1550 2410 -1550 {lab=row_n[2]}
N 2060 -1530 2070 -1540 {lab=rowon_n[2]}
N 2070 -1540 2270 -1540 {lab=rowon_n[2]}
N 2270 -1540 2280 -1530 {lab=rowon_n[2]}
N 2280 -1530 2410 -1530 {lab=rowon_n[2]}
N 2270 -1520 2280 -1510 {lab=#net3}
N 2280 -1510 2410 -1510 {lab=#net3}
N 2060 -1490 2070 -1500 {lab=#net4}
N 2070 -1500 2270 -1500 {lab=#net4}
N 2270 -1500 2280 -1490 {lab=#net4}
N 2280 -1490 2410 -1490 {lab=#net4}
N 2060 -1510 2070 -1520 {lab=#net3}
N 2070 -1520 2270 -1520 {lab=#net3}
N 2410 -1570 2420 -1580 {lab=rowoff_n[2]}
N 2420 -1580 2620 -1580 {lab=rowoff_n[2]}
N 2620 -1580 2630 -1570 {lab=rowoff_n[2]}
N 2630 -1570 2750 -1570 {lab=rowoff_n[2]}
N 2410 -1550 2420 -1560 {lab=row_n[2]}
N 2420 -1560 2620 -1560 {lab=row_n[2]}
N 2620 -1560 2630 -1550 {lab=row_n[2]}
N 2630 -1550 2750 -1550 {lab=row_n[2]}
N 2410 -1530 2420 -1540 {lab=rowon_n[2]}
N 2420 -1540 2620 -1540 {lab=rowon_n[2]}
N 2620 -1540 2630 -1530 {lab=rowon_n[2]}
N 2630 -1530 2750 -1530 {lab=rowon_n[2]}
N 2410 -1510 2420 -1520 {lab=#net3}
N 2420 -1520 2620 -1520 {lab=#net3}
N 2620 -1520 2630 -1510 {lab=#net3}
N 2630 -1510 2750 -1510 {lab=#net3}
N 2410 -1490 2420 -1500 {lab=#net4}
N 2420 -1500 2620 -1500 {lab=#net4}
N 2620 -1500 2630 -1490 {lab=#net4}
N 2630 -1490 2750 -1490 {lab=#net4}
N 2750 -1570 2760 -1580 {lab=rowoff_n[2]}
N 2760 -1580 2960 -1580 {lab=rowoff_n[2]}
N 2960 -1580 2970 -1570 {lab=rowoff_n[2]}
N 2970 -1570 3100 -1570 {lab=rowoff_n[2]}
N 2750 -1550 2760 -1560 {lab=row_n[2]}
N 2760 -1560 2960 -1560 {lab=row_n[2]}
N 2960 -1560 2970 -1550 {lab=row_n[2]}
N 2970 -1550 3100 -1550 {lab=row_n[2]}
N 2750 -1530 2760 -1540 {lab=rowon_n[2]}
N 2760 -1540 2960 -1540 {lab=rowon_n[2]}
N 2960 -1540 2970 -1530 {lab=rowon_n[2]}
N 2970 -1530 3100 -1530 {lab=rowon_n[2]}
N 2750 -1510 2760 -1520 {lab=#net3}
N 2760 -1520 2960 -1520 {lab=#net3}
N 2750 -1490 2760 -1500 {lab=#net4}
N 2760 -1500 2960 -1500 {lab=#net4}
N 2960 -1500 2970 -1490 {lab=#net4}
N 2970 -1490 3100 -1490 {lab=#net4}
N 2960 -1520 2970 -1510 {lab=#net3}
N 2970 -1510 3100 -1510 {lab=#net3}
N 3100 -1570 3110 -1580 {lab=rowoff_n[2]}
N 3110 -1580 3310 -1580 {lab=rowoff_n[2]}
N 3310 -1580 3320 -1570 {lab=rowoff_n[2]}
N 3320 -1570 3460 -1570 {lab=rowoff_n[2]}
N 3100 -1550 3110 -1560 {lab=row_n[2]}
N 3110 -1560 3310 -1560 {lab=row_n[2]}
N 3310 -1560 3320 -1550 {lab=row_n[2]}
N 3320 -1550 3460 -1550 {lab=row_n[2]}
N 3100 -1530 3110 -1540 {lab=rowon_n[2]}
N 3110 -1540 3310 -1540 {lab=rowon_n[2]}
N 3310 -1540 3320 -1530 {lab=rowon_n[2]}
N 3320 -1530 3460 -1530 {lab=rowon_n[2]}
N 3100 -1510 3110 -1520 {lab=#net3}
N 3110 -1520 3310 -1520 {lab=#net3}
N 3310 -1520 3320 -1510 {lab=#net3}
N 3320 -1510 3460 -1510 {lab=#net3}
N 3100 -1490 3110 -1500 {lab=#net4}
N 3110 -1500 3310 -1500 {lab=#net4}
N 3310 -1500 3320 -1490 {lab=#net4}
N 3320 -1490 3460 -1490 {lab=#net4}
N 3460 -1570 3470 -1580 {lab=rowoff_n[2]}
N 3470 -1580 3670 -1580 {lab=rowoff_n[2]}
N 3670 -1580 3680 -1570 {lab=rowoff_n[2]}
N 3680 -1570 3790 -1570 {lab=rowoff_n[2]}
N 3460 -1550 3470 -1560 {lab=row_n[2]}
N 3470 -1560 3670 -1560 {lab=row_n[2]}
N 3670 -1560 3680 -1550 {lab=row_n[2]}
N 3680 -1550 3790 -1550 {lab=row_n[2]}
N 3460 -1530 3470 -1540 {lab=rowon_n[2]}
N 3470 -1540 3670 -1540 {lab=rowon_n[2]}
N 3670 -1540 3680 -1530 {lab=rowon_n[2]}
N 3680 -1530 3790 -1530 {lab=rowon_n[2]}
N 3460 -1510 3470 -1520 {lab=#net3}
N 3470 -1520 3670 -1520 {lab=#net3}
N 3670 -1520 3680 -1510 {lab=#net3}
N 3680 -1510 3790 -1510 {lab=#net3}
N 3460 -1490 3470 -1500 {lab=#net4}
N 3470 -1500 3670 -1500 {lab=#net4}
N 3670 -1500 3680 -1490 {lab=#net4}
N 3680 -1490 3790 -1490 {lab=#net4}
N 3790 -1570 3800 -1580 {lab=rowoff_n[2]}
N 3800 -1580 4000 -1580 {lab=rowoff_n[2]}
N 4000 -1580 4010 -1570 {lab=rowoff_n[2]}
N 4010 -1570 4120 -1570 {lab=rowoff_n[2]}
N 3790 -1550 3800 -1560 {lab=row_n[2]}
N 3800 -1560 4000 -1560 {lab=row_n[2]}
N 4000 -1560 4010 -1550 {lab=row_n[2]}
N 4010 -1550 4120 -1550 {lab=row_n[2]}
N 3790 -1530 3800 -1540 {lab=rowon_n[2]}
N 3800 -1540 4000 -1540 {lab=rowon_n[2]}
N 4000 -1540 4010 -1530 {lab=rowon_n[2]}
N 4010 -1530 4120 -1530 {lab=rowon_n[2]}
N 3790 -1510 3800 -1520 {lab=#net3}
N 3800 -1520 4000 -1520 {lab=#net3}
N 4000 -1520 4010 -1510 {lab=#net3}
N 4010 -1510 4120 -1510 {lab=#net3}
N 3790 -1490 3800 -1500 {lab=#net4}
N 3800 -1500 4000 -1500 {lab=#net4}
N 4000 -1500 4020 -1490 {lab=#net4}
N 4020 -1490 4120 -1490 {lab=#net4}
N 4120 -1570 4130 -1580 {lab=rowoff_n[2]}
N 4130 -1580 4330 -1580 {lab=rowoff_n[2]}
N 4330 -1580 4340 -1570 {lab=rowoff_n[2]}
N 4340 -1570 4470 -1570 {lab=rowoff_n[2]}
N 4120 -1550 4130 -1560 {lab=row_n[2]}
N 4130 -1560 4330 -1560 {lab=row_n[2]}
N 4330 -1560 4340 -1550 {lab=row_n[2]}
N 4340 -1550 4470 -1550 {lab=row_n[2]}
N 4120 -1530 4130 -1540 {lab=rowon_n[2]}
N 4130 -1540 4330 -1540 {lab=rowon_n[2]}
N 4330 -1540 4340 -1530 {lab=rowon_n[2]}
N 4340 -1530 4470 -1530 {lab=rowon_n[2]}
N 4120 -1510 4130 -1520 {lab=#net3}
N 4130 -1520 4330 -1520 {lab=#net3}
N 4330 -1520 4340 -1510 {lab=#net3}
N 4340 -1510 4470 -1510 {lab=#net3}
N 4120 -1490 4130 -1500 {lab=#net4}
N 4130 -1500 4330 -1500 {lab=#net4}
N 4330 -1500 4340 -1490 {lab=#net4}
N 4340 -1490 4470 -1490 {lab=#net4}
N 4470 -1570 4480 -1580 {lab=rowoff_n[2]}
N 4480 -1580 4680 -1580 {lab=rowoff_n[2]}
N 4680 -1580 4690 -1570 {lab=rowoff_n[2]}
N 4690 -1570 4820 -1570 {lab=rowoff_n[2]}
N 4470 -1550 4480 -1560 {lab=row_n[2]}
N 4480 -1560 4680 -1560 {lab=row_n[2]}
N 4470 -1530 4480 -1540 {lab=rowon_n[2]}
N 4480 -1540 4680 -1540 {lab=rowon_n[2]}
N 4680 -1540 4690 -1530 {lab=rowon_n[2]}
N 4690 -1530 4820 -1530 {lab=rowon_n[2]}
N 4680 -1560 4690 -1550 {lab=row_n[2]}
N 4690 -1550 4820 -1550 {lab=row_n[2]}
N 4470 -1510 4480 -1520 {lab=#net3}
N 4480 -1520 4680 -1520 {lab=#net3}
N 4680 -1520 4690 -1510 {lab=#net3}
N 4690 -1510 4820 -1510 {lab=#net3}
N 4470 -1490 4480 -1500 {lab=#net4}
N 4480 -1500 4680 -1500 {lab=#net4}
N 4680 -1500 4690 -1490 {lab=#net4}
N 4690 -1490 4820 -1490 {lab=#net4}
N 4820 -1570 4830 -1580 {lab=rowoff_n[2]}
N 4830 -1580 5030 -1580 {lab=rowoff_n[2]}
N 5030 -1580 5040 -1570 {lab=rowoff_n[2]}
N 5040 -1570 5160 -1570 {lab=rowoff_n[2]}
N 4820 -1550 4830 -1560 {lab=row_n[2]}
N 4830 -1560 5030 -1560 {lab=row_n[2]}
N 5030 -1560 5040 -1550 {lab=row_n[2]}
N 5040 -1550 5160 -1550 {lab=row_n[2]}
N 4820 -1530 4830 -1540 {lab=rowon_n[2]}
N 4830 -1540 5030 -1540 {lab=rowon_n[2]}
N 5030 -1540 5040 -1530 {lab=rowon_n[2]}
N 5040 -1530 5160 -1530 {lab=rowon_n[2]}
N 4820 -1510 4830 -1520 {lab=#net3}
N 4830 -1520 5030 -1520 {lab=#net3}
N 5030 -1520 5040 -1510 {lab=#net3}
N 5040 -1510 5160 -1510 {lab=#net3}
N 4820 -1490 4830 -1500 {lab=#net4}
N 4830 -1500 5030 -1500 {lab=#net4}
N 5030 -1500 5040 -1490 {lab=#net4}
N 5040 -1490 5160 -1490 {lab=#net4}
N 5160 -1570 5170 -1580 {lab=rowoff_n[2]}
N 5170 -1580 5370 -1580 {lab=rowoff_n[2]}
N 5370 -1580 5380 -1570 {lab=rowoff_n[2]}
N 5380 -1570 5500 -1570 {lab=rowoff_n[2]}
N 5160 -1550 5170 -1560 {lab=row_n[2]}
N 5170 -1560 5370 -1560 {lab=row_n[2]}
N 5370 -1560 5380 -1550 {lab=row_n[2]}
N 5380 -1550 5500 -1550 {lab=row_n[2]}
N 5160 -1530 5170 -1540 {lab=rowon_n[2]}
N 5170 -1540 5370 -1540 {lab=rowon_n[2]}
N 5370 -1540 5380 -1530 {lab=rowon_n[2]}
N 5380 -1530 5500 -1530 {lab=rowon_n[2]}
N 5160 -1510 5170 -1520 {lab=#net3}
N 5170 -1520 5370 -1520 {lab=#net3}
N 5370 -1520 5380 -1510 {lab=#net3}
N 5380 -1510 5500 -1510 {lab=#net3}
N 5160 -1490 5170 -1500 {lab=#net4}
N 5170 -1500 5370 -1500 {lab=#net4}
N 5370 -1500 5390 -1490 {lab=#net4}
N 5390 -1490 5500 -1490 {lab=#net4}
N 5500 -1570 5510 -1580 {lab=rowoff_n[2]}
N 5510 -1580 5710 -1580 {lab=rowoff_n[2]}
N 5500 -1550 5510 -1560 {lab=row_n[2]}
N 5510 -1560 5710 -1560 {lab=row_n[2]}
N 5710 -1560 5720 -1550 {lab=row_n[2]}
N 5710 -1580 5720 -1570 {lab=rowoff_n[2]}
N 5500 -1530 5510 -1540 {lab=rowon_n[2]}
N 5510 -1540 5710 -1540 {lab=rowon_n[2]}
N 5500 -1510 5510 -1520 {lab=#net3}
N 5510 -1520 5710 -1520 {lab=#net3}
N 5710 -1520 5720 -1510 {lab=#net3}
N 5500 -1490 5510 -1500 {lab=#net4}
N 5510 -1500 5710 -1500 {lab=#net4}
N 5710 -1500 5720 -1490 {lab=#net4}
N 5710 -1540 5720 -1530 {lab=rowon_n[2]}
N 830 -1080 840 -1090 {lab=VDD}
N 840 -1340 840 -1090 {lab=VDD}
N 830 -1350 840 -1340 {lab=VDD}
N 830 -1410 830 -1350 {lab=VDD}
N 850 -1410 850 -1350 {lab=VSS}
N 850 -1350 860 -1340 {lab=VSS}
N 860 -1340 860 -1090 {lab=VSS}
N 850 -1080 860 -1090 {lab=VSS}
N 1160 -1340 1160 -1090 {lab=col_n[0]}
N 1150 -1350 1160 -1340 {lab=col_n[0]}
N 1150 -1410 1150 -1350 {lab=col_n[0]}
N 1170 -1410 1170 -1350 {lab=col[0]}
N 1170 -1350 1180 -1340 {lab=col[0]}
N 1180 -1340 1180 -1090 {lab=col[0]}
N 1490 -1340 1490 -1090 {lab=col_n[1]}
N 1480 -1350 1490 -1340 {lab=col_n[1]}
N 1480 -1410 1480 -1350 {lab=col_n[1]}
N 1500 -1410 1500 -1350 {lab=col[1]}
N 1500 -1350 1510 -1340 {lab=col[1]}
N 1510 -1340 1510 -1090 {lab=col[1]}
N 1840 -1340 1840 -1090 {lab=col_n[2]}
N 1830 -1350 1840 -1340 {lab=col_n[2]}
N 1830 -1410 1830 -1350 {lab=col_n[2]}
N 1850 -1410 1850 -1350 {lab=col[2]}
N 1850 -1350 1860 -1340 {lab=col[2]}
N 1860 -1340 1860 -1090 {lab=col[2]}
N 2190 -1340 2190 -1090 {lab=col_n[3]}
N 2180 -1350 2190 -1340 {lab=col_n[3]}
N 2180 -1410 2180 -1350 {lab=col_n[3]}
N 2200 -1410 2200 -1350 {lab=col[3]}
N 2200 -1350 2210 -1340 {lab=col[3]}
N 2210 -1340 2210 -1090 {lab=col[3]}
N 2540 -1340 2540 -1090 {lab=col_n[4]}
N 2530 -1350 2540 -1340 {lab=col_n[4]}
N 2530 -1410 2530 -1350 {lab=col_n[4]}
N 2550 -1410 2550 -1350 {lab=col[4]}
N 2550 -1350 2560 -1340 {lab=col[4]}
N 2560 -1340 2560 -1090 {lab=col[4]}
N 2880 -1340 2880 -1090 {lab=col_n[5]}
N 2870 -1350 2880 -1340 {lab=col_n[5]}
N 2870 -1410 2870 -1350 {lab=col_n[5]}
N 2890 -1410 2890 -1350 {lab=col[5]}
N 2890 -1350 2900 -1340 {lab=col[5]}
N 2900 -1340 2900 -1090 {lab=col[5]}
N 3230 -1340 3230 -1090 {lab=col_n[6]}
N 3220 -1350 3230 -1340 {lab=col_n[6]}
N 3220 -1410 3220 -1350 {lab=col_n[6]}
N 3240 -1410 3240 -1350 {lab=col[6]}
N 3240 -1350 3250 -1340 {lab=col[6]}
N 3250 -1340 3250 -1090 {lab=col[6]}
N 3590 -1340 3590 -1090 {lab=col_n[7]}
N 3580 -1350 3590 -1340 {lab=col_n[7]}
N 3580 -1410 3580 -1350 {lab=col_n[7]}
N 3600 -1410 3600 -1350 {lab=col[7]}
N 3600 -1350 3610 -1340 {lab=col[7]}
N 3610 -1340 3610 -1090 {lab=col[7]}
N 3920 -1340 3920 -1090 {lab=col_n[8]}
N 3910 -1350 3920 -1340 {lab=col_n[8]}
N 3910 -1410 3910 -1350 {lab=col_n[8]}
N 3930 -1410 3930 -1350 {lab=col[8]}
N 3930 -1350 3940 -1340 {lab=col[8]}
N 3940 -1340 3940 -1090 {lab=col[8]}
N 4250 -1340 4250 -1090 {lab=col_n[9]}
N 4240 -1350 4250 -1340 {lab=col_n[9]}
N 4240 -1410 4240 -1350 {lab=col_n[9]}
N 4260 -1410 4260 -1350 {lab=col[9]}
N 4260 -1350 4270 -1340 {lab=col[9]}
N 4270 -1340 4270 -1090 {lab=col[9]}
N 4600 -1340 4600 -1090 {lab=col_n[10]}
N 4590 -1350 4600 -1340 {lab=col_n[10]}
N 4590 -1410 4590 -1350 {lab=col_n[10]}
N 4610 -1410 4610 -1350 {lab=col[10]}
N 4610 -1350 4620 -1340 {lab=col[10]}
N 4620 -1340 4620 -1090 {lab=col[10]}
N 4950 -1340 4950 -1090 {lab=col_n[11]}
N 4940 -1350 4950 -1340 {lab=col_n[11]}
N 4940 -1410 4940 -1350 {lab=col_n[11]}
N 4960 -1410 4960 -1350 {lab=col[11]}
N 4960 -1350 4970 -1340 {lab=col[11]}
N 4970 -1340 4970 -1090 {lab=col[11]}
N 5290 -1340 5290 -1090 {lab=col_n[12]}
N 5280 -1350 5290 -1340 {lab=col_n[12]}
N 5280 -1410 5280 -1350 {lab=col_n[12]}
N 5300 -1410 5300 -1350 {lab=col[12]}
N 5300 -1350 5310 -1340 {lab=col[12]}
N 5310 -1340 5310 -1090 {lab=col[12]}
N 5630 -1340 5630 -1090 {lab=VDD}
N 5620 -1350 5630 -1340 {lab=VDD}
N 5620 -1410 5620 -1350 {lab=VDD}
N 5640 -1410 5640 -1350 {lab=VSS}
N 5640 -1350 5650 -1340 {lab=VSS}
N 5650 -1340 5650 -1090 {lab=VSS}
N 5640 -1080 5650 -1090 {lab=VSS}
N 5620 -1080 5630 -1090 {lab=VDD}
N 5280 -1080 5290 -1090 {lab=col_n[12]}
N 5300 -1080 5310 -1090 {lab=col[12]}
N 4940 -1080 4950 -1090 {lab=col_n[11]}
N 4960 -1080 4970 -1090 {lab=col[11]}
N 4590 -1080 4600 -1090 {lab=col_n[10]}
N 4610 -1080 4620 -1090 {lab=col[10]}
N 4260 -1080 4270 -1090 {lab=col[9]}
N 4240 -1080 4250 -1090 {lab=col_n[9]}
N 3930 -1080 3940 -1090 {lab=col[8]}
N 3910 -1080 3920 -1090 {lab=col_n[8]}
N 3580 -1080 3590 -1090 {lab=col_n[7]}
N 3600 -1080 3610 -1090 {lab=col[7]}
N 3220 -1080 3230 -1090 {lab=col_n[6]}
N 3240 -1080 3250 -1090 {lab=col[6]}
N 2890 -1080 2900 -1090 {lab=col[5]}
N 2870 -1080 2880 -1090 {lab=col_n[5]}
N 2550 -1080 2560 -1090 {lab=col[4]}
N 2530 -1080 2540 -1090 {lab=col_n[4]}
N 2200 -1080 2210 -1090 {lab=col[3]}
N 2180 -1080 2190 -1090 {lab=col_n[3]}
N 1850 -1080 1860 -1090 {lab=col[2]}
N 1830 -1080 1840 -1090 {lab=col_n[2]}
N 1500 -1080 1510 -1090 {lab=col[1]}
N 1480 -1080 1490 -1090 {lab=col_n[1]}
N 1150 -1080 1160 -1090 {lab=col_n[0]}
N 1170 -1080 1180 -1090 {lab=col[0]}
N 830 -1040 840 -1030 {lab=VDD}
N 830 -1080 830 -1040 {lab=VDD}
N 850 -1080 850 -1040 {lab=VSS}
N 850 -1040 860 -1030 {lab=VSS}
N 750 -1730 750 -1720 {
lab=VSS}
N 1070 -1730 1070 -1720 {
lab=VSS}
N 1400 -1730 1400 -1720 {
lab=VSS}
N 1750 -1730 1750 -1720 {
lab=VSS}
N 2100 -1730 2100 -1720 {
lab=VSS}
N 2450 -1730 2450 -1720 {
lab=VSS}
N 2790 -1730 2790 -1720 {
lab=VSS}
N 3140 -1730 3140 -1720 {
lab=VSS}
N 3500 -1730 3500 -1720 {
lab=VSS}
N 3830 -1730 3830 -1720 {
lab=VSS}
N 4160 -1730 4160 -1720 {
lab=VSS}
N 4510 -1730 4510 -1720 {
lab=VSS}
N 4860 -1730 4860 -1720 {
lab=VSS}
N 5200 -1730 5200 -1720 {
lab=VSS}
N 5540 -1730 5540 -1720 {
lab=VSS}
N 5560 -1970 5560 -1950 {
lab=vcm}
N 5540 -1960 5540 -1950 {
lab=VDD}
N 5600 -1970 5600 -1950 {
lab=ctop}
N 4880 -1970 4880 -1950 {
lab=vcm}
N 4860 -1960 4860 -1950 {
lab=VDD}
N 4920 -1970 4920 -1950 {
lab=ctop}
N 5220 -1970 5220 -1950 {
lab=vcm}
N 5200 -1960 5200 -1950 {
lab=VDD}
N 5260 -1970 5260 -1950 {
lab=ctop}
N 4530 -1970 4530 -1950 {
lab=vcm}
N 4510 -1960 4510 -1950 {
lab=VDD}
N 4570 -1970 4570 -1950 {
lab=ctop}
N 4180 -1970 4180 -1950 {
lab=vcm}
N 4160 -1960 4160 -1950 {
lab=VDD}
N 4220 -1970 4220 -1950 {
lab=ctop}
N 3850 -1970 3850 -1950 {
lab=vcm}
N 3830 -1960 3830 -1950 {
lab=VDD}
N 3890 -1970 3890 -1950 {
lab=ctop}
N 3520 -1970 3520 -1950 {
lab=vcm}
N 3500 -1960 3500 -1950 {
lab=VDD}
N 3560 -1970 3560 -1950 {
lab=ctop}
N 3160 -1970 3160 -1950 {
lab=vcm}
N 3140 -1960 3140 -1950 {
lab=VDD}
N 3200 -1970 3200 -1950 {
lab=ctop}
N 2810 -1970 2810 -1950 {
lab=vcm}
N 2790 -1960 2790 -1950 {
lab=VDD}
N 2850 -1970 2850 -1950 {
lab=ctop}
N 2470 -1970 2470 -1950 {
lab=vcm}
N 2450 -1960 2450 -1950 {
lab=VDD}
N 2510 -1970 2510 -1950 {
lab=ctop}
N 2120 -1970 2120 -1950 {
lab=vcm}
N 2100 -1960 2100 -1950 {
lab=VDD}
N 2160 -1970 2160 -1950 {
lab=ctop}
N 1770 -1970 1770 -1950 {
lab=vcm}
N 1750 -1960 1750 -1950 {
lab=VDD}
N 1810 -1970 1810 -1950 {
lab=ctop}
N 1420 -1970 1420 -1950 {
lab=vcm}
N 1400 -1960 1400 -1950 {
lab=VDD}
N 1460 -1970 1460 -1950 {
lab=ctop}
N 1090 -1970 1090 -1950 {
lab=vcm}
N 1070 -1960 1070 -1950 {
lab=VDD}
N 1130 -1970 1130 -1950 {
lab=ctop}
N 770 -1970 770 -1950 {
lab=vcm}
N 750 -1960 750 -1950 {
lab=VDD}
N 810 -1970 810 -1950 {
lab=ctop}
N 690 -1810 710 -1810 {
lab=sample_n}
N 690 -1830 710 -1830 {
lab=sample}
N 690 -1850 710 -1850 {
lab=rowon_n[3]}
N 690 -1870 710 -1870 {
lab=row_n[3]}
N 690 -1890 710 -1890 {
lab=rowoff_n[3]}
N 930 -1830 1030 -1830 {lab=#net5}
N 930 -1810 1030 -1810 {lab=#net6}
N 710 -1890 720 -1900 {lab=rowoff_n[3]}
N 720 -1900 940 -1900 {lab=rowoff_n[3]}
N 940 -1900 950 -1890 {lab=rowoff_n[3]}
N 950 -1890 1030 -1890 {lab=rowoff_n[3]}
N 710 -1870 720 -1880 {lab=row_n[3]}
N 720 -1880 940 -1880 {lab=row_n[3]}
N 940 -1880 950 -1870 {lab=row_n[3]}
N 950 -1870 1030 -1870 {lab=row_n[3]}
N 710 -1850 720 -1860 {lab=rowon_n[3]}
N 720 -1860 940 -1860 {lab=rowon_n[3]}
N 940 -1860 950 -1850 {lab=rowon_n[3]}
N 950 -1850 1030 -1850 {lab=rowon_n[3]}
N 1030 -1890 1040 -1900 {lab=rowoff_n[3]}
N 1030 -1870 1040 -1880 {lab=row_n[3]}
N 1040 -1880 1240 -1880 {lab=row_n[3]}
N 1240 -1880 1250 -1870 {lab=row_n[3]}
N 1250 -1870 1360 -1870 {lab=row_n[3]}
N 1040 -1900 1240 -1900 {lab=rowoff_n[3]}
N 1240 -1900 1250 -1890 {lab=rowoff_n[3]}
N 1250 -1890 1360 -1890 {lab=rowoff_n[3]}
N 1030 -1850 1040 -1860 {lab=rowon_n[3]}
N 1040 -1860 1240 -1860 {lab=rowon_n[3]}
N 1240 -1860 1250 -1850 {lab=rowon_n[3]}
N 1250 -1850 1360 -1850 {lab=rowon_n[3]}
N 1030 -1830 1040 -1840 {lab=#net5}
N 1040 -1840 1240 -1840 {lab=#net5}
N 1240 -1840 1250 -1830 {lab=#net5}
N 1250 -1830 1360 -1830 {lab=#net5}
N 1030 -1810 1040 -1820 {lab=#net6}
N 1040 -1820 1240 -1820 {lab=#net6}
N 1240 -1820 1250 -1810 {lab=#net6}
N 1250 -1810 1360 -1810 {lab=#net6}
N 1360 -1870 1370 -1880 {lab=row_n[3]}
N 1370 -1880 1570 -1880 {lab=row_n[3]}
N 1570 -1880 1580 -1870 {lab=row_n[3]}
N 1580 -1870 1710 -1870 {lab=row_n[3]}
N 1360 -1850 1370 -1860 {lab=rowon_n[3]}
N 1370 -1860 1570 -1860 {lab=rowon_n[3]}
N 1570 -1860 1580 -1850 {lab=rowon_n[3]}
N 1580 -1850 1710 -1850 {lab=rowon_n[3]}
N 1360 -1830 1370 -1840 {lab=#net5}
N 1370 -1840 1570 -1840 {lab=#net5}
N 1570 -1840 1580 -1830 {lab=#net5}
N 1580 -1830 1710 -1830 {lab=#net5}
N 1360 -1810 1380 -1820 {lab=#net6}
N 1380 -1820 1570 -1820 {lab=#net6}
N 1570 -1820 1580 -1810 {lab=#net6}
N 1580 -1810 1710 -1810 {lab=#net6}
N 1360 -1890 1370 -1900 {lab=rowoff_n[3]}
N 1370 -1900 1570 -1900 {lab=rowoff_n[3]}
N 1570 -1900 1580 -1890 {lab=rowoff_n[3]}
N 1580 -1890 1710 -1890 {lab=rowoff_n[3]}
N 1710 -1890 1720 -1900 {lab=rowoff_n[3]}
N 1720 -1900 1920 -1900 {lab=rowoff_n[3]}
N 1920 -1900 1930 -1890 {lab=rowoff_n[3]}
N 1930 -1890 2060 -1890 {lab=rowoff_n[3]}
N 1710 -1870 1720 -1880 {lab=row_n[3]}
N 1720 -1880 1920 -1880 {lab=row_n[3]}
N 1920 -1880 1930 -1870 {lab=row_n[3]}
N 1930 -1870 2060 -1870 {lab=row_n[3]}
N 1710 -1850 1720 -1860 {lab=rowon_n[3]}
N 1720 -1860 1920 -1860 {lab=rowon_n[3]}
N 1920 -1860 1930 -1850 {lab=rowon_n[3]}
N 1930 -1850 2060 -1850 {lab=rowon_n[3]}
N 1710 -1830 1720 -1840 {lab=#net5}
N 1720 -1840 1920 -1840 {lab=#net5}
N 1920 -1840 1930 -1830 {lab=#net5}
N 1930 -1830 2060 -1830 {lab=#net5}
N 1710 -1810 1720 -1820 {lab=#net6}
N 1720 -1820 1920 -1820 {lab=#net6}
N 1920 -1820 1930 -1810 {lab=#net6}
N 1930 -1810 2060 -1810 {lab=#net6}
N 2060 -1890 2070 -1900 {lab=rowoff_n[3]}
N 2070 -1900 2270 -1900 {lab=rowoff_n[3]}
N 2270 -1900 2280 -1890 {lab=rowoff_n[3]}
N 2280 -1890 2410 -1890 {lab=rowoff_n[3]}
N 2060 -1870 2070 -1880 {lab=row_n[3]}
N 2070 -1880 2270 -1880 {lab=row_n[3]}
N 2270 -1880 2280 -1870 {lab=row_n[3]}
N 2280 -1870 2410 -1870 {lab=row_n[3]}
N 2060 -1850 2070 -1860 {lab=rowon_n[3]}
N 2070 -1860 2270 -1860 {lab=rowon_n[3]}
N 2270 -1860 2280 -1850 {lab=rowon_n[3]}
N 2280 -1850 2410 -1850 {lab=rowon_n[3]}
N 2270 -1840 2280 -1830 {lab=#net5}
N 2280 -1830 2410 -1830 {lab=#net5}
N 2060 -1810 2070 -1820 {lab=#net6}
N 2070 -1820 2270 -1820 {lab=#net6}
N 2270 -1820 2280 -1810 {lab=#net6}
N 2280 -1810 2410 -1810 {lab=#net6}
N 2060 -1830 2070 -1840 {lab=#net5}
N 2070 -1840 2270 -1840 {lab=#net5}
N 2410 -1890 2420 -1900 {lab=rowoff_n[3]}
N 2420 -1900 2620 -1900 {lab=rowoff_n[3]}
N 2620 -1900 2630 -1890 {lab=rowoff_n[3]}
N 2630 -1890 2750 -1890 {lab=rowoff_n[3]}
N 2410 -1870 2420 -1880 {lab=row_n[3]}
N 2420 -1880 2620 -1880 {lab=row_n[3]}
N 2620 -1880 2630 -1870 {lab=row_n[3]}
N 2630 -1870 2750 -1870 {lab=row_n[3]}
N 2410 -1850 2420 -1860 {lab=rowon_n[3]}
N 2420 -1860 2620 -1860 {lab=rowon_n[3]}
N 2620 -1860 2630 -1850 {lab=rowon_n[3]}
N 2630 -1850 2750 -1850 {lab=rowon_n[3]}
N 2410 -1830 2420 -1840 {lab=#net5}
N 2420 -1840 2620 -1840 {lab=#net5}
N 2620 -1840 2630 -1830 {lab=#net5}
N 2630 -1830 2750 -1830 {lab=#net5}
N 2410 -1810 2420 -1820 {lab=#net6}
N 2420 -1820 2620 -1820 {lab=#net6}
N 2620 -1820 2630 -1810 {lab=#net6}
N 2630 -1810 2750 -1810 {lab=#net6}
N 2750 -1890 2760 -1900 {lab=rowoff_n[3]}
N 2760 -1900 2960 -1900 {lab=rowoff_n[3]}
N 2960 -1900 2970 -1890 {lab=rowoff_n[3]}
N 2970 -1890 3100 -1890 {lab=rowoff_n[3]}
N 2750 -1870 2760 -1880 {lab=row_n[3]}
N 2760 -1880 2960 -1880 {lab=row_n[3]}
N 2960 -1880 2970 -1870 {lab=row_n[3]}
N 2970 -1870 3100 -1870 {lab=row_n[3]}
N 2750 -1850 2760 -1860 {lab=rowon_n[3]}
N 2760 -1860 2960 -1860 {lab=rowon_n[3]}
N 2960 -1860 2970 -1850 {lab=rowon_n[3]}
N 2970 -1850 3100 -1850 {lab=rowon_n[3]}
N 2750 -1830 2760 -1840 {lab=#net5}
N 2760 -1840 2960 -1840 {lab=#net5}
N 2750 -1810 2760 -1820 {lab=#net6}
N 2760 -1820 2960 -1820 {lab=#net6}
N 2960 -1820 2970 -1810 {lab=#net6}
N 2970 -1810 3100 -1810 {lab=#net6}
N 2960 -1840 2970 -1830 {lab=#net5}
N 2970 -1830 3100 -1830 {lab=#net5}
N 3100 -1890 3110 -1900 {lab=rowoff_n[3]}
N 3110 -1900 3310 -1900 {lab=rowoff_n[3]}
N 3310 -1900 3320 -1890 {lab=rowoff_n[3]}
N 3320 -1890 3460 -1890 {lab=rowoff_n[3]}
N 3100 -1870 3110 -1880 {lab=row_n[3]}
N 3110 -1880 3310 -1880 {lab=row_n[3]}
N 3310 -1880 3320 -1870 {lab=row_n[3]}
N 3320 -1870 3460 -1870 {lab=row_n[3]}
N 3100 -1850 3110 -1860 {lab=rowon_n[3]}
N 3110 -1860 3310 -1860 {lab=rowon_n[3]}
N 3310 -1860 3320 -1850 {lab=rowon_n[3]}
N 3320 -1850 3460 -1850 {lab=rowon_n[3]}
N 3100 -1830 3110 -1840 {lab=#net5}
N 3110 -1840 3310 -1840 {lab=#net5}
N 3310 -1840 3320 -1830 {lab=#net5}
N 3320 -1830 3460 -1830 {lab=#net5}
N 3100 -1810 3110 -1820 {lab=#net6}
N 3110 -1820 3310 -1820 {lab=#net6}
N 3310 -1820 3320 -1810 {lab=#net6}
N 3320 -1810 3460 -1810 {lab=#net6}
N 3460 -1890 3470 -1900 {lab=rowoff_n[3]}
N 3470 -1900 3670 -1900 {lab=rowoff_n[3]}
N 3670 -1900 3680 -1890 {lab=rowoff_n[3]}
N 3680 -1890 3790 -1890 {lab=rowoff_n[3]}
N 3460 -1870 3470 -1880 {lab=row_n[3]}
N 3470 -1880 3670 -1880 {lab=row_n[3]}
N 3670 -1880 3680 -1870 {lab=row_n[3]}
N 3680 -1870 3790 -1870 {lab=row_n[3]}
N 3460 -1850 3470 -1860 {lab=rowon_n[3]}
N 3470 -1860 3670 -1860 {lab=rowon_n[3]}
N 3670 -1860 3680 -1850 {lab=rowon_n[3]}
N 3680 -1850 3790 -1850 {lab=rowon_n[3]}
N 3460 -1830 3470 -1840 {lab=#net5}
N 3470 -1840 3670 -1840 {lab=#net5}
N 3670 -1840 3680 -1830 {lab=#net5}
N 3680 -1830 3790 -1830 {lab=#net5}
N 3460 -1810 3470 -1820 {lab=#net6}
N 3470 -1820 3670 -1820 {lab=#net6}
N 3670 -1820 3680 -1810 {lab=#net6}
N 3680 -1810 3790 -1810 {lab=#net6}
N 3790 -1890 3800 -1900 {lab=rowoff_n[3]}
N 3800 -1900 4000 -1900 {lab=rowoff_n[3]}
N 4000 -1900 4010 -1890 {lab=rowoff_n[3]}
N 4010 -1890 4120 -1890 {lab=rowoff_n[3]}
N 3790 -1870 3800 -1880 {lab=row_n[3]}
N 3800 -1880 4000 -1880 {lab=row_n[3]}
N 4000 -1880 4010 -1870 {lab=row_n[3]}
N 4010 -1870 4120 -1870 {lab=row_n[3]}
N 3790 -1850 3800 -1860 {lab=rowon_n[3]}
N 3800 -1860 4000 -1860 {lab=rowon_n[3]}
N 4000 -1860 4010 -1850 {lab=rowon_n[3]}
N 4010 -1850 4120 -1850 {lab=rowon_n[3]}
N 3790 -1830 3800 -1840 {lab=#net5}
N 3800 -1840 4000 -1840 {lab=#net5}
N 4000 -1840 4010 -1830 {lab=#net5}
N 4010 -1830 4120 -1830 {lab=#net5}
N 3790 -1810 3800 -1820 {lab=#net6}
N 3800 -1820 4000 -1820 {lab=#net6}
N 4000 -1820 4020 -1810 {lab=#net6}
N 4020 -1810 4120 -1810 {lab=#net6}
N 4120 -1890 4130 -1900 {lab=rowoff_n[3]}
N 4130 -1900 4330 -1900 {lab=rowoff_n[3]}
N 4330 -1900 4340 -1890 {lab=rowoff_n[3]}
N 4340 -1890 4470 -1890 {lab=rowoff_n[3]}
N 4120 -1870 4130 -1880 {lab=row_n[3]}
N 4130 -1880 4330 -1880 {lab=row_n[3]}
N 4330 -1880 4340 -1870 {lab=row_n[3]}
N 4340 -1870 4470 -1870 {lab=row_n[3]}
N 4120 -1850 4130 -1860 {lab=rowon_n[3]}
N 4130 -1860 4330 -1860 {lab=rowon_n[3]}
N 4330 -1860 4340 -1850 {lab=rowon_n[3]}
N 4340 -1850 4470 -1850 {lab=rowon_n[3]}
N 4120 -1830 4130 -1840 {lab=#net5}
N 4130 -1840 4330 -1840 {lab=#net5}
N 4330 -1840 4340 -1830 {lab=#net5}
N 4340 -1830 4470 -1830 {lab=#net5}
N 4120 -1810 4130 -1820 {lab=#net6}
N 4130 -1820 4330 -1820 {lab=#net6}
N 4330 -1820 4340 -1810 {lab=#net6}
N 4340 -1810 4470 -1810 {lab=#net6}
N 4470 -1890 4480 -1900 {lab=rowoff_n[3]}
N 4480 -1900 4680 -1900 {lab=rowoff_n[3]}
N 4680 -1900 4690 -1890 {lab=rowoff_n[3]}
N 4690 -1890 4820 -1890 {lab=rowoff_n[3]}
N 4470 -1870 4480 -1880 {lab=row_n[3]}
N 4480 -1880 4680 -1880 {lab=row_n[3]}
N 4470 -1850 4480 -1860 {lab=rowon_n[3]}
N 4480 -1860 4680 -1860 {lab=rowon_n[3]}
N 4680 -1860 4690 -1850 {lab=rowon_n[3]}
N 4690 -1850 4820 -1850 {lab=rowon_n[3]}
N 4680 -1880 4690 -1870 {lab=row_n[3]}
N 4690 -1870 4820 -1870 {lab=row_n[3]}
N 4470 -1830 4480 -1840 {lab=#net5}
N 4480 -1840 4680 -1840 {lab=#net5}
N 4680 -1840 4690 -1830 {lab=#net5}
N 4690 -1830 4820 -1830 {lab=#net5}
N 4470 -1810 4480 -1820 {lab=#net6}
N 4480 -1820 4680 -1820 {lab=#net6}
N 4680 -1820 4690 -1810 {lab=#net6}
N 4690 -1810 4820 -1810 {lab=#net6}
N 4820 -1890 4830 -1900 {lab=rowoff_n[3]}
N 4830 -1900 5030 -1900 {lab=rowoff_n[3]}
N 5030 -1900 5040 -1890 {lab=rowoff_n[3]}
N 5040 -1890 5160 -1890 {lab=rowoff_n[3]}
N 4820 -1870 4830 -1880 {lab=row_n[3]}
N 4830 -1880 5030 -1880 {lab=row_n[3]}
N 5030 -1880 5040 -1870 {lab=row_n[3]}
N 5040 -1870 5160 -1870 {lab=row_n[3]}
N 4820 -1850 4830 -1860 {lab=rowon_n[3]}
N 4830 -1860 5030 -1860 {lab=rowon_n[3]}
N 5030 -1860 5040 -1850 {lab=rowon_n[3]}
N 5040 -1850 5160 -1850 {lab=rowon_n[3]}
N 4820 -1830 4830 -1840 {lab=#net5}
N 4830 -1840 5030 -1840 {lab=#net5}
N 5030 -1840 5040 -1830 {lab=#net5}
N 5040 -1830 5160 -1830 {lab=#net5}
N 4820 -1810 4830 -1820 {lab=#net6}
N 4830 -1820 5030 -1820 {lab=#net6}
N 5030 -1820 5040 -1810 {lab=#net6}
N 5040 -1810 5160 -1810 {lab=#net6}
N 5160 -1890 5170 -1900 {lab=rowoff_n[3]}
N 5170 -1900 5370 -1900 {lab=rowoff_n[3]}
N 5370 -1900 5380 -1890 {lab=rowoff_n[3]}
N 5380 -1890 5500 -1890 {lab=rowoff_n[3]}
N 5160 -1870 5170 -1880 {lab=row_n[3]}
N 5170 -1880 5370 -1880 {lab=row_n[3]}
N 5370 -1880 5380 -1870 {lab=row_n[3]}
N 5380 -1870 5500 -1870 {lab=row_n[3]}
N 5160 -1850 5170 -1860 {lab=rowon_n[3]}
N 5170 -1860 5370 -1860 {lab=rowon_n[3]}
N 5370 -1860 5380 -1850 {lab=rowon_n[3]}
N 5380 -1850 5500 -1850 {lab=rowon_n[3]}
N 5160 -1830 5170 -1840 {lab=#net5}
N 5170 -1840 5370 -1840 {lab=#net5}
N 5370 -1840 5380 -1830 {lab=#net5}
N 5380 -1830 5500 -1830 {lab=#net5}
N 5160 -1810 5170 -1820 {lab=#net6}
N 5170 -1820 5370 -1820 {lab=#net6}
N 5370 -1820 5390 -1810 {lab=#net6}
N 5390 -1810 5500 -1810 {lab=#net6}
N 5500 -1890 5510 -1900 {lab=rowoff_n[3]}
N 5510 -1900 5710 -1900 {lab=rowoff_n[3]}
N 5500 -1870 5510 -1880 {lab=row_n[3]}
N 5510 -1880 5710 -1880 {lab=row_n[3]}
N 5710 -1880 5720 -1870 {lab=row_n[3]}
N 5710 -1900 5720 -1890 {lab=rowoff_n[3]}
N 5500 -1850 5510 -1860 {lab=rowon_n[3]}
N 5510 -1860 5710 -1860 {lab=rowon_n[3]}
N 5500 -1830 5510 -1840 {lab=#net5}
N 5510 -1840 5710 -1840 {lab=#net5}
N 5710 -1840 5720 -1830 {lab=#net5}
N 5500 -1810 5510 -1820 {lab=#net6}
N 5510 -1820 5710 -1820 {lab=#net6}
N 5710 -1820 5720 -1810 {lab=#net6}
N 5710 -1860 5720 -1850 {lab=rowon_n[3]}
N 750 -2060 750 -2050 {
lab=VSS}
N 1070 -2060 1070 -2050 {
lab=VSS}
N 1400 -2060 1400 -2050 {
lab=VSS}
N 1750 -2060 1750 -2050 {
lab=VSS}
N 2100 -2060 2100 -2050 {
lab=VSS}
N 2450 -2060 2450 -2050 {
lab=VSS}
N 2790 -2060 2790 -2050 {
lab=VSS}
N 3140 -2060 3140 -2050 {
lab=VSS}
N 3500 -2060 3500 -2050 {
lab=VSS}
N 3830 -2060 3830 -2050 {
lab=VSS}
N 4160 -2060 4160 -2050 {
lab=VSS}
N 4510 -2060 4510 -2050 {
lab=VSS}
N 4860 -2060 4860 -2050 {
lab=VSS}
N 5200 -2060 5200 -2050 {
lab=VSS}
N 5540 -2060 5540 -2050 {
lab=VSS}
N 5560 -2300 5560 -2280 {
lab=vcm}
N 5540 -2290 5540 -2280 {
lab=VDD}
N 5600 -2300 5600 -2280 {
lab=ctop}
N 4880 -2300 4880 -2280 {
lab=vcm}
N 4860 -2290 4860 -2280 {
lab=VDD}
N 4920 -2300 4920 -2280 {
lab=ctop}
N 5220 -2300 5220 -2280 {
lab=vcm}
N 5200 -2290 5200 -2280 {
lab=VDD}
N 5260 -2300 5260 -2280 {
lab=ctop}
N 4530 -2300 4530 -2280 {
lab=vcm}
N 4510 -2290 4510 -2280 {
lab=VDD}
N 4570 -2300 4570 -2280 {
lab=ctop}
N 4180 -2300 4180 -2280 {
lab=vcm}
N 4160 -2290 4160 -2280 {
lab=VDD}
N 4220 -2300 4220 -2280 {
lab=ctop}
N 3850 -2300 3850 -2280 {
lab=vcm}
N 3830 -2290 3830 -2280 {
lab=VDD}
N 3890 -2300 3890 -2280 {
lab=ctop}
N 3520 -2300 3520 -2280 {
lab=vcm}
N 3500 -2290 3500 -2280 {
lab=VDD}
N 3560 -2300 3560 -2280 {
lab=ctop}
N 3160 -2300 3160 -2280 {
lab=vcm}
N 3140 -2290 3140 -2280 {
lab=VDD}
N 3200 -2300 3200 -2280 {
lab=ctop}
N 2810 -2300 2810 -2280 {
lab=vcm}
N 2790 -2290 2790 -2280 {
lab=VDD}
N 2850 -2300 2850 -2280 {
lab=ctop}
N 2470 -2300 2470 -2280 {
lab=vcm}
N 2450 -2290 2450 -2280 {
lab=VDD}
N 2510 -2300 2510 -2280 {
lab=ctop}
N 2120 -2300 2120 -2280 {
lab=vcm}
N 2100 -2290 2100 -2280 {
lab=VDD}
N 2160 -2300 2160 -2280 {
lab=ctop}
N 1770 -2300 1770 -2280 {
lab=vcm}
N 1750 -2290 1750 -2280 {
lab=VDD}
N 1810 -2300 1810 -2280 {
lab=ctop}
N 1420 -2300 1420 -2280 {
lab=vcm}
N 1400 -2290 1400 -2280 {
lab=VDD}
N 1460 -2300 1460 -2280 {
lab=ctop}
N 1090 -2300 1090 -2280 {
lab=vcm}
N 1070 -2290 1070 -2280 {
lab=VDD}
N 1130 -2300 1130 -2280 {
lab=ctop}
N 770 -2300 770 -2280 {
lab=vcm}
N 750 -2290 750 -2280 {
lab=VDD}
N 810 -2300 810 -2280 {
lab=ctop}
N 690 -2140 710 -2140 {
lab=sample_n}
N 690 -2160 710 -2160 {
lab=sample}
N 690 -2180 710 -2180 {
lab=rowon_n[4]}
N 690 -2200 710 -2200 {
lab=row_n[4]}
N 690 -2220 710 -2220 {
lab=rowoff_n[4]}
N 930 -2160 1030 -2160 {lab=#net7}
N 930 -2140 1030 -2140 {lab=#net8}
N 710 -2220 720 -2230 {lab=rowoff_n[4]}
N 720 -2230 940 -2230 {lab=rowoff_n[4]}
N 940 -2230 950 -2220 {lab=rowoff_n[4]}
N 950 -2220 1030 -2220 {lab=rowoff_n[4]}
N 710 -2200 720 -2210 {lab=row_n[4]}
N 720 -2210 940 -2210 {lab=row_n[4]}
N 940 -2210 950 -2200 {lab=row_n[4]}
N 950 -2200 1030 -2200 {lab=row_n[4]}
N 710 -2180 720 -2190 {lab=rowon_n[4]}
N 720 -2190 940 -2190 {lab=rowon_n[4]}
N 940 -2190 950 -2180 {lab=rowon_n[4]}
N 950 -2180 1030 -2180 {lab=rowon_n[4]}
N 1030 -2220 1040 -2230 {lab=rowoff_n[4]}
N 1030 -2200 1040 -2210 {lab=row_n[4]}
N 1040 -2210 1240 -2210 {lab=row_n[4]}
N 1240 -2210 1250 -2200 {lab=row_n[4]}
N 1250 -2200 1360 -2200 {lab=row_n[4]}
N 1040 -2230 1240 -2230 {lab=rowoff_n[4]}
N 1240 -2230 1250 -2220 {lab=rowoff_n[4]}
N 1250 -2220 1360 -2220 {lab=rowoff_n[4]}
N 1030 -2180 1040 -2190 {lab=rowon_n[4]}
N 1040 -2190 1240 -2190 {lab=rowon_n[4]}
N 1240 -2190 1250 -2180 {lab=rowon_n[4]}
N 1250 -2180 1360 -2180 {lab=rowon_n[4]}
N 1030 -2160 1040 -2170 {lab=#net7}
N 1040 -2170 1240 -2170 {lab=#net7}
N 1240 -2170 1250 -2160 {lab=#net7}
N 1250 -2160 1360 -2160 {lab=#net7}
N 1030 -2140 1040 -2150 {lab=#net8}
N 1040 -2150 1240 -2150 {lab=#net8}
N 1240 -2150 1250 -2140 {lab=#net8}
N 1250 -2140 1360 -2140 {lab=#net8}
N 1360 -2200 1370 -2210 {lab=row_n[4]}
N 1370 -2210 1570 -2210 {lab=row_n[4]}
N 1570 -2210 1580 -2200 {lab=row_n[4]}
N 1580 -2200 1710 -2200 {lab=row_n[4]}
N 1360 -2180 1370 -2190 {lab=rowon_n[4]}
N 1370 -2190 1570 -2190 {lab=rowon_n[4]}
N 1570 -2190 1580 -2180 {lab=rowon_n[4]}
N 1580 -2180 1710 -2180 {lab=rowon_n[4]}
N 1360 -2160 1370 -2170 {lab=#net7}
N 1370 -2170 1570 -2170 {lab=#net7}
N 1570 -2170 1580 -2160 {lab=#net7}
N 1580 -2160 1710 -2160 {lab=#net7}
N 1360 -2140 1380 -2150 {lab=#net8}
N 1380 -2150 1570 -2150 {lab=#net8}
N 1570 -2150 1580 -2140 {lab=#net8}
N 1580 -2140 1710 -2140 {lab=#net8}
N 1360 -2220 1370 -2230 {lab=rowoff_n[4]}
N 1370 -2230 1570 -2230 {lab=rowoff_n[4]}
N 1570 -2230 1580 -2220 {lab=rowoff_n[4]}
N 1580 -2220 1710 -2220 {lab=rowoff_n[4]}
N 1710 -2220 1720 -2230 {lab=rowoff_n[4]}
N 1720 -2230 1920 -2230 {lab=rowoff_n[4]}
N 1920 -2230 1930 -2220 {lab=rowoff_n[4]}
N 1930 -2220 2060 -2220 {lab=rowoff_n[4]}
N 1710 -2200 1720 -2210 {lab=row_n[4]}
N 1720 -2210 1920 -2210 {lab=row_n[4]}
N 1920 -2210 1930 -2200 {lab=row_n[4]}
N 1930 -2200 2060 -2200 {lab=row_n[4]}
N 1710 -2180 1720 -2190 {lab=rowon_n[4]}
N 1720 -2190 1920 -2190 {lab=rowon_n[4]}
N 1920 -2190 1930 -2180 {lab=rowon_n[4]}
N 1930 -2180 2060 -2180 {lab=rowon_n[4]}
N 1710 -2160 1720 -2170 {lab=#net7}
N 1720 -2170 1920 -2170 {lab=#net7}
N 1920 -2170 1930 -2160 {lab=#net7}
N 1930 -2160 2060 -2160 {lab=#net7}
N 1710 -2140 1720 -2150 {lab=#net8}
N 1720 -2150 1920 -2150 {lab=#net8}
N 1920 -2150 1930 -2140 {lab=#net8}
N 1930 -2140 2060 -2140 {lab=#net8}
N 2060 -2220 2070 -2230 {lab=rowoff_n[4]}
N 2070 -2230 2270 -2230 {lab=rowoff_n[4]}
N 2270 -2230 2280 -2220 {lab=rowoff_n[4]}
N 2280 -2220 2410 -2220 {lab=rowoff_n[4]}
N 2060 -2200 2070 -2210 {lab=row_n[4]}
N 2070 -2210 2270 -2210 {lab=row_n[4]}
N 2270 -2210 2280 -2200 {lab=row_n[4]}
N 2280 -2200 2410 -2200 {lab=row_n[4]}
N 2060 -2180 2070 -2190 {lab=rowon_n[4]}
N 2070 -2190 2270 -2190 {lab=rowon_n[4]}
N 2270 -2190 2280 -2180 {lab=rowon_n[4]}
N 2280 -2180 2410 -2180 {lab=rowon_n[4]}
N 2270 -2170 2280 -2160 {lab=#net7}
N 2280 -2160 2410 -2160 {lab=#net7}
N 2060 -2140 2070 -2150 {lab=#net8}
N 2070 -2150 2270 -2150 {lab=#net8}
N 2270 -2150 2280 -2140 {lab=#net8}
N 2280 -2140 2410 -2140 {lab=#net8}
N 2060 -2160 2070 -2170 {lab=#net7}
N 2070 -2170 2270 -2170 {lab=#net7}
N 2410 -2220 2420 -2230 {lab=rowoff_n[4]}
N 2420 -2230 2620 -2230 {lab=rowoff_n[4]}
N 2620 -2230 2630 -2220 {lab=rowoff_n[4]}
N 2630 -2220 2750 -2220 {lab=rowoff_n[4]}
N 2410 -2200 2420 -2210 {lab=row_n[4]}
N 2420 -2210 2620 -2210 {lab=row_n[4]}
N 2620 -2210 2630 -2200 {lab=row_n[4]}
N 2630 -2200 2750 -2200 {lab=row_n[4]}
N 2410 -2180 2420 -2190 {lab=rowon_n[4]}
N 2420 -2190 2620 -2190 {lab=rowon_n[4]}
N 2620 -2190 2630 -2180 {lab=rowon_n[4]}
N 2630 -2180 2750 -2180 {lab=rowon_n[4]}
N 2410 -2160 2420 -2170 {lab=#net7}
N 2420 -2170 2620 -2170 {lab=#net7}
N 2620 -2170 2630 -2160 {lab=#net7}
N 2630 -2160 2750 -2160 {lab=#net7}
N 2410 -2140 2420 -2150 {lab=#net8}
N 2420 -2150 2620 -2150 {lab=#net8}
N 2620 -2150 2630 -2140 {lab=#net8}
N 2630 -2140 2750 -2140 {lab=#net8}
N 2750 -2220 2760 -2230 {lab=rowoff_n[4]}
N 2760 -2230 2960 -2230 {lab=rowoff_n[4]}
N 2960 -2230 2970 -2220 {lab=rowoff_n[4]}
N 2970 -2220 3100 -2220 {lab=rowoff_n[4]}
N 2750 -2200 2760 -2210 {lab=row_n[4]}
N 2760 -2210 2960 -2210 {lab=row_n[4]}
N 2960 -2210 2970 -2200 {lab=row_n[4]}
N 2970 -2200 3100 -2200 {lab=row_n[4]}
N 2750 -2180 2760 -2190 {lab=rowon_n[4]}
N 2760 -2190 2960 -2190 {lab=rowon_n[4]}
N 2960 -2190 2970 -2180 {lab=rowon_n[4]}
N 2970 -2180 3100 -2180 {lab=rowon_n[4]}
N 2750 -2160 2760 -2170 {lab=#net7}
N 2760 -2170 2960 -2170 {lab=#net7}
N 2750 -2140 2760 -2150 {lab=#net8}
N 2760 -2150 2960 -2150 {lab=#net8}
N 2960 -2150 2970 -2140 {lab=#net8}
N 2970 -2140 3100 -2140 {lab=#net8}
N 2960 -2170 2970 -2160 {lab=#net7}
N 2970 -2160 3100 -2160 {lab=#net7}
N 3100 -2220 3110 -2230 {lab=rowoff_n[4]}
N 3110 -2230 3310 -2230 {lab=rowoff_n[4]}
N 3310 -2230 3320 -2220 {lab=rowoff_n[4]}
N 3320 -2220 3460 -2220 {lab=rowoff_n[4]}
N 3100 -2200 3110 -2210 {lab=row_n[4]}
N 3110 -2210 3310 -2210 {lab=row_n[4]}
N 3310 -2210 3320 -2200 {lab=row_n[4]}
N 3320 -2200 3460 -2200 {lab=row_n[4]}
N 3100 -2180 3110 -2190 {lab=rowon_n[4]}
N 3110 -2190 3310 -2190 {lab=rowon_n[4]}
N 3310 -2190 3320 -2180 {lab=rowon_n[4]}
N 3320 -2180 3460 -2180 {lab=rowon_n[4]}
N 3100 -2160 3110 -2170 {lab=#net7}
N 3110 -2170 3310 -2170 {lab=#net7}
N 3310 -2170 3320 -2160 {lab=#net7}
N 3320 -2160 3460 -2160 {lab=#net7}
N 3100 -2140 3110 -2150 {lab=#net8}
N 3110 -2150 3310 -2150 {lab=#net8}
N 3310 -2150 3320 -2140 {lab=#net8}
N 3320 -2140 3460 -2140 {lab=#net8}
N 3460 -2220 3470 -2230 {lab=rowoff_n[4]}
N 3470 -2230 3670 -2230 {lab=rowoff_n[4]}
N 3670 -2230 3680 -2220 {lab=rowoff_n[4]}
N 3680 -2220 3790 -2220 {lab=rowoff_n[4]}
N 3460 -2200 3470 -2210 {lab=row_n[4]}
N 3470 -2210 3670 -2210 {lab=row_n[4]}
N 3670 -2210 3680 -2200 {lab=row_n[4]}
N 3680 -2200 3790 -2200 {lab=row_n[4]}
N 3460 -2180 3470 -2190 {lab=rowon_n[4]}
N 3470 -2190 3670 -2190 {lab=rowon_n[4]}
N 3670 -2190 3680 -2180 {lab=rowon_n[4]}
N 3680 -2180 3790 -2180 {lab=rowon_n[4]}
N 3460 -2160 3470 -2170 {lab=#net7}
N 3470 -2170 3670 -2170 {lab=#net7}
N 3670 -2170 3680 -2160 {lab=#net7}
N 3680 -2160 3790 -2160 {lab=#net7}
N 3460 -2140 3470 -2150 {lab=#net8}
N 3470 -2150 3670 -2150 {lab=#net8}
N 3670 -2150 3680 -2140 {lab=#net8}
N 3680 -2140 3790 -2140 {lab=#net8}
N 3790 -2220 3800 -2230 {lab=rowoff_n[4]}
N 3800 -2230 4000 -2230 {lab=rowoff_n[4]}
N 4000 -2230 4010 -2220 {lab=rowoff_n[4]}
N 4010 -2220 4120 -2220 {lab=rowoff_n[4]}
N 3790 -2200 3800 -2210 {lab=row_n[4]}
N 3800 -2210 4000 -2210 {lab=row_n[4]}
N 4000 -2210 4010 -2200 {lab=row_n[4]}
N 4010 -2200 4120 -2200 {lab=row_n[4]}
N 3790 -2180 3800 -2190 {lab=rowon_n[4]}
N 3800 -2190 4000 -2190 {lab=rowon_n[4]}
N 4000 -2190 4010 -2180 {lab=rowon_n[4]}
N 4010 -2180 4120 -2180 {lab=rowon_n[4]}
N 3790 -2160 3800 -2170 {lab=#net7}
N 3800 -2170 4000 -2170 {lab=#net7}
N 4000 -2170 4010 -2160 {lab=#net7}
N 4010 -2160 4120 -2160 {lab=#net7}
N 3790 -2140 3800 -2150 {lab=#net8}
N 3800 -2150 4000 -2150 {lab=#net8}
N 4000 -2150 4020 -2140 {lab=#net8}
N 4020 -2140 4120 -2140 {lab=#net8}
N 4120 -2220 4130 -2230 {lab=rowoff_n[4]}
N 4130 -2230 4330 -2230 {lab=rowoff_n[4]}
N 4330 -2230 4340 -2220 {lab=rowoff_n[4]}
N 4340 -2220 4470 -2220 {lab=rowoff_n[4]}
N 4120 -2200 4130 -2210 {lab=row_n[4]}
N 4130 -2210 4330 -2210 {lab=row_n[4]}
N 4330 -2210 4340 -2200 {lab=row_n[4]}
N 4340 -2200 4470 -2200 {lab=row_n[4]}
N 4120 -2180 4130 -2190 {lab=rowon_n[4]}
N 4130 -2190 4330 -2190 {lab=rowon_n[4]}
N 4330 -2190 4340 -2180 {lab=rowon_n[4]}
N 4340 -2180 4470 -2180 {lab=rowon_n[4]}
N 4120 -2160 4130 -2170 {lab=#net7}
N 4130 -2170 4330 -2170 {lab=#net7}
N 4330 -2170 4340 -2160 {lab=#net7}
N 4340 -2160 4470 -2160 {lab=#net7}
N 4120 -2140 4130 -2150 {lab=#net8}
N 4130 -2150 4330 -2150 {lab=#net8}
N 4330 -2150 4340 -2140 {lab=#net8}
N 4340 -2140 4470 -2140 {lab=#net8}
N 4470 -2220 4480 -2230 {lab=rowoff_n[4]}
N 4480 -2230 4680 -2230 {lab=rowoff_n[4]}
N 4680 -2230 4690 -2220 {lab=rowoff_n[4]}
N 4690 -2220 4820 -2220 {lab=rowoff_n[4]}
N 4470 -2200 4480 -2210 {lab=row_n[4]}
N 4480 -2210 4680 -2210 {lab=row_n[4]}
N 4470 -2180 4480 -2190 {lab=rowon_n[4]}
N 4480 -2190 4680 -2190 {lab=rowon_n[4]}
N 4680 -2190 4690 -2180 {lab=rowon_n[4]}
N 4690 -2180 4820 -2180 {lab=rowon_n[4]}
N 4680 -2210 4690 -2200 {lab=row_n[4]}
N 4690 -2200 4820 -2200 {lab=row_n[4]}
N 4470 -2160 4480 -2170 {lab=#net7}
N 4480 -2170 4680 -2170 {lab=#net7}
N 4680 -2170 4690 -2160 {lab=#net7}
N 4690 -2160 4820 -2160 {lab=#net7}
N 4470 -2140 4480 -2150 {lab=#net8}
N 4480 -2150 4680 -2150 {lab=#net8}
N 4680 -2150 4690 -2140 {lab=#net8}
N 4690 -2140 4820 -2140 {lab=#net8}
N 4820 -2220 4830 -2230 {lab=rowoff_n[4]}
N 4830 -2230 5030 -2230 {lab=rowoff_n[4]}
N 5030 -2230 5040 -2220 {lab=rowoff_n[4]}
N 5040 -2220 5160 -2220 {lab=rowoff_n[4]}
N 4820 -2200 4830 -2210 {lab=row_n[4]}
N 4830 -2210 5030 -2210 {lab=row_n[4]}
N 5030 -2210 5040 -2200 {lab=row_n[4]}
N 5040 -2200 5160 -2200 {lab=row_n[4]}
N 4820 -2180 4830 -2190 {lab=rowon_n[4]}
N 4830 -2190 5030 -2190 {lab=rowon_n[4]}
N 5030 -2190 5040 -2180 {lab=rowon_n[4]}
N 5040 -2180 5160 -2180 {lab=rowon_n[4]}
N 4820 -2160 4830 -2170 {lab=#net7}
N 4830 -2170 5030 -2170 {lab=#net7}
N 5030 -2170 5040 -2160 {lab=#net7}
N 5040 -2160 5160 -2160 {lab=#net7}
N 4820 -2140 4830 -2150 {lab=#net8}
N 4830 -2150 5030 -2150 {lab=#net8}
N 5030 -2150 5040 -2140 {lab=#net8}
N 5040 -2140 5160 -2140 {lab=#net8}
N 5160 -2220 5170 -2230 {lab=rowoff_n[4]}
N 5170 -2230 5370 -2230 {lab=rowoff_n[4]}
N 5370 -2230 5380 -2220 {lab=rowoff_n[4]}
N 5380 -2220 5500 -2220 {lab=rowoff_n[4]}
N 5160 -2200 5170 -2210 {lab=row_n[4]}
N 5170 -2210 5370 -2210 {lab=row_n[4]}
N 5370 -2210 5380 -2200 {lab=row_n[4]}
N 5380 -2200 5500 -2200 {lab=row_n[4]}
N 5160 -2180 5170 -2190 {lab=rowon_n[4]}
N 5170 -2190 5370 -2190 {lab=rowon_n[4]}
N 5370 -2190 5380 -2180 {lab=rowon_n[4]}
N 5380 -2180 5500 -2180 {lab=rowon_n[4]}
N 5160 -2160 5170 -2170 {lab=#net7}
N 5170 -2170 5370 -2170 {lab=#net7}
N 5370 -2170 5380 -2160 {lab=#net7}
N 5380 -2160 5500 -2160 {lab=#net7}
N 5160 -2140 5170 -2150 {lab=#net8}
N 5170 -2150 5370 -2150 {lab=#net8}
N 5370 -2150 5390 -2140 {lab=#net8}
N 5390 -2140 5500 -2140 {lab=#net8}
N 5500 -2220 5510 -2230 {lab=rowoff_n[4]}
N 5510 -2230 5710 -2230 {lab=rowoff_n[4]}
N 5500 -2200 5510 -2210 {lab=row_n[4]}
N 5510 -2210 5710 -2210 {lab=row_n[4]}
N 5710 -2210 5720 -2200 {lab=row_n[4]}
N 5710 -2230 5720 -2220 {lab=rowoff_n[4]}
N 5500 -2180 5510 -2190 {lab=rowon_n[4]}
N 5510 -2190 5710 -2190 {lab=rowon_n[4]}
N 5500 -2160 5510 -2170 {lab=#net7}
N 5510 -2170 5710 -2170 {lab=#net7}
N 5710 -2170 5720 -2160 {lab=#net7}
N 5500 -2140 5510 -2150 {lab=#net8}
N 5510 -2150 5710 -2150 {lab=#net8}
N 5710 -2150 5720 -2140 {lab=#net8}
N 5710 -2190 5720 -2180 {lab=rowon_n[4]}
N 830 -1730 840 -1740 {lab=VDD}
N 840 -1990 840 -1740 {lab=VDD}
N 830 -2000 840 -1990 {lab=VDD}
N 830 -2060 830 -2000 {lab=VDD}
N 850 -2060 850 -2000 {lab=VSS}
N 850 -2000 860 -1990 {lab=VSS}
N 860 -1990 860 -1740 {lab=VSS}
N 850 -1730 860 -1740 {lab=VSS}
N 1160 -1990 1160 -1740 {lab=col_n[0]}
N 1150 -2000 1160 -1990 {lab=col_n[0]}
N 1150 -2060 1150 -2000 {lab=col_n[0]}
N 1170 -2060 1170 -2000 {lab=col[0]}
N 1170 -2000 1180 -1990 {lab=col[0]}
N 1180 -1990 1180 -1740 {lab=col[0]}
N 1490 -1990 1490 -1740 {lab=col_n[1]}
N 1480 -2000 1490 -1990 {lab=col_n[1]}
N 1480 -2060 1480 -2000 {lab=col_n[1]}
N 1500 -2060 1500 -2000 {lab=col[1]}
N 1500 -2000 1510 -1990 {lab=col[1]}
N 1510 -1990 1510 -1740 {lab=col[1]}
N 1840 -1990 1840 -1740 {lab=col_n[2]}
N 1830 -2000 1840 -1990 {lab=col_n[2]}
N 1830 -2060 1830 -2000 {lab=col_n[2]}
N 1850 -2060 1850 -2000 {lab=col[2]}
N 1850 -2000 1860 -1990 {lab=col[2]}
N 1860 -1990 1860 -1740 {lab=col[2]}
N 2190 -1990 2190 -1740 {lab=col_n[3]}
N 2180 -2000 2190 -1990 {lab=col_n[3]}
N 2180 -2060 2180 -2000 {lab=col_n[3]}
N 2200 -2060 2200 -2000 {lab=col[3]}
N 2200 -2000 2210 -1990 {lab=col[3]}
N 2210 -1990 2210 -1740 {lab=col[3]}
N 2540 -1990 2540 -1740 {lab=col_n[4]}
N 2530 -2000 2540 -1990 {lab=col_n[4]}
N 2530 -2060 2530 -2000 {lab=col_n[4]}
N 2550 -2060 2550 -2000 {lab=col[4]}
N 2550 -2000 2560 -1990 {lab=col[4]}
N 2560 -1990 2560 -1740 {lab=col[4]}
N 2880 -1990 2880 -1740 {lab=col_n[5]}
N 2870 -2000 2880 -1990 {lab=col_n[5]}
N 2870 -2060 2870 -2000 {lab=col_n[5]}
N 2890 -2060 2890 -2000 {lab=col[5]}
N 2890 -2000 2900 -1990 {lab=col[5]}
N 2900 -1990 2900 -1740 {lab=col[5]}
N 3230 -1990 3230 -1740 {lab=col_n[6]}
N 3220 -2000 3230 -1990 {lab=col_n[6]}
N 3220 -2060 3220 -2000 {lab=col_n[6]}
N 3240 -2060 3240 -2000 {lab=col[6]}
N 3240 -2000 3250 -1990 {lab=col[6]}
N 3250 -1990 3250 -1740 {lab=col[6]}
N 3590 -1990 3590 -1740 {lab=col_n[7]}
N 3580 -2000 3590 -1990 {lab=col_n[7]}
N 3580 -2060 3580 -2000 {lab=col_n[7]}
N 3600 -2060 3600 -2000 {lab=col[7]}
N 3600 -2000 3610 -1990 {lab=col[7]}
N 3610 -1990 3610 -1740 {lab=col[7]}
N 3920 -1990 3920 -1740 {lab=col_n[8]}
N 3910 -2000 3920 -1990 {lab=col_n[8]}
N 3910 -2060 3910 -2000 {lab=col_n[8]}
N 3930 -2060 3930 -2000 {lab=col[8]}
N 3930 -2000 3940 -1990 {lab=col[8]}
N 3940 -1990 3940 -1740 {lab=col[8]}
N 4250 -1990 4250 -1740 {lab=col_n[9]}
N 4240 -2000 4250 -1990 {lab=col_n[9]}
N 4240 -2060 4240 -2000 {lab=col_n[9]}
N 4260 -2060 4260 -2000 {lab=col[9]}
N 4260 -2000 4270 -1990 {lab=col[9]}
N 4270 -1990 4270 -1740 {lab=col[9]}
N 4600 -1990 4600 -1740 {lab=col_n[10]}
N 4590 -2000 4600 -1990 {lab=col_n[10]}
N 4590 -2060 4590 -2000 {lab=col_n[10]}
N 4610 -2060 4610 -2000 {lab=col[10]}
N 4610 -2000 4620 -1990 {lab=col[10]}
N 4620 -1990 4620 -1740 {lab=col[10]}
N 4950 -1990 4950 -1740 {lab=col_n[11]}
N 4940 -2000 4950 -1990 {lab=col_n[11]}
N 4940 -2060 4940 -2000 {lab=col_n[11]}
N 4960 -2060 4960 -2000 {lab=col[11]}
N 4960 -2000 4970 -1990 {lab=col[11]}
N 4970 -1990 4970 -1740 {lab=col[11]}
N 5290 -1990 5290 -1740 {lab=col_n[12]}
N 5280 -2000 5290 -1990 {lab=col_n[12]}
N 5280 -2060 5280 -2000 {lab=col_n[12]}
N 5300 -2060 5300 -2000 {lab=col[12]}
N 5300 -2000 5310 -1990 {lab=col[12]}
N 5310 -1990 5310 -1740 {lab=col[12]}
N 5630 -1990 5630 -1740 {lab=VDD}
N 5620 -2000 5630 -1990 {lab=VDD}
N 5620 -2060 5620 -2000 {lab=VDD}
N 5640 -2060 5640 -2000 {lab=VSS}
N 5640 -2000 5650 -1990 {lab=VSS}
N 5650 -1990 5650 -1740 {lab=VSS}
N 5640 -1730 5650 -1740 {lab=VSS}
N 5620 -1730 5630 -1740 {lab=VDD}
N 5280 -1730 5290 -1740 {lab=col_n[12]}
N 5300 -1730 5310 -1740 {lab=col[12]}
N 4940 -1730 4950 -1740 {lab=col_n[11]}
N 4960 -1730 4970 -1740 {lab=col[11]}
N 4590 -1730 4600 -1740 {lab=col_n[10]}
N 4610 -1730 4620 -1740 {lab=col[10]}
N 4260 -1730 4270 -1740 {lab=col[9]}
N 4240 -1730 4250 -1740 {lab=col_n[9]}
N 3930 -1730 3940 -1740 {lab=col[8]}
N 3910 -1730 3920 -1740 {lab=col_n[8]}
N 3580 -1730 3590 -1740 {lab=col_n[7]}
N 3600 -1730 3610 -1740 {lab=col[7]}
N 3220 -1730 3230 -1740 {lab=col_n[6]}
N 3240 -1730 3250 -1740 {lab=col[6]}
N 2890 -1730 2900 -1740 {lab=col[5]}
N 2870 -1730 2880 -1740 {lab=col_n[5]}
N 2550 -1730 2560 -1740 {lab=col[4]}
N 2530 -1730 2540 -1740 {lab=col_n[4]}
N 2200 -1730 2210 -1740 {lab=col[3]}
N 2180 -1730 2190 -1740 {lab=col_n[3]}
N 1850 -1730 1860 -1740 {lab=col[2]}
N 1830 -1730 1840 -1740 {lab=col_n[2]}
N 1500 -1730 1510 -1740 {lab=col[1]}
N 1480 -1730 1490 -1740 {lab=col_n[1]}
N 1150 -1730 1160 -1740 {lab=col_n[0]}
N 1170 -1730 1180 -1740 {lab=col[0]}
N 830 -1730 830 -1690 {lab=VDD}
N 850 -1730 850 -1690 {lab=VSS}
N 830 -1410 840 -1420 {lab=VDD}
N 840 -1680 840 -1420 {lab=VDD}
N 830 -1690 840 -1680 {lab=VDD}
N 850 -1690 860 -1680 {lab=VSS}
N 860 -1680 860 -1420 {lab=VSS}
N 850 -1410 860 -1420 {lab=VSS}
N 1150 -1730 1150 -1690 {lab=col_n[0]}
N 1170 -1730 1170 -1690 {lab=col[0]}
N 1160 -1680 1160 -1420 {lab=col_n[0]}
N 1150 -1690 1160 -1680 {lab=col_n[0]}
N 1170 -1690 1180 -1680 {lab=col[0]}
N 1180 -1680 1180 -1420 {lab=col[0]}
N 1480 -1730 1480 -1690 {lab=col_n[1]}
N 1500 -1730 1500 -1690 {lab=col[1]}
N 1490 -1680 1490 -1420 {lab=col_n[1]}
N 1480 -1690 1490 -1680 {lab=col_n[1]}
N 1500 -1690 1510 -1680 {lab=col[1]}
N 1510 -1680 1510 -1420 {lab=col[1]}
N 1830 -1730 1830 -1690 {lab=col_n[2]}
N 1850 -1730 1850 -1690 {lab=col[2]}
N 1840 -1680 1840 -1420 {lab=col_n[2]}
N 1830 -1690 1840 -1680 {lab=col_n[2]}
N 1850 -1690 1860 -1680 {lab=col[2]}
N 1860 -1680 1860 -1420 {lab=col[2]}
N 2180 -1730 2180 -1690 {lab=col_n[3]}
N 2200 -1730 2200 -1690 {lab=col[3]}
N 2190 -1680 2190 -1420 {lab=col_n[3]}
N 2180 -1690 2190 -1680 {lab=col_n[3]}
N 2200 -1690 2210 -1680 {lab=col[3]}
N 2210 -1680 2210 -1420 {lab=col[3]}
N 2530 -1730 2530 -1690 {lab=col_n[4]}
N 2550 -1730 2550 -1690 {lab=col[4]}
N 2540 -1680 2540 -1420 {lab=col_n[4]}
N 2530 -1690 2540 -1680 {lab=col_n[4]}
N 2550 -1690 2560 -1680 {lab=col[4]}
N 2560 -1680 2560 -1420 {lab=col[4]}
N 2870 -1730 2870 -1690 {lab=col_n[5]}
N 2890 -1730 2890 -1690 {lab=col[5]}
N 2880 -1680 2880 -1420 {lab=col_n[5]}
N 2870 -1690 2880 -1680 {lab=col_n[5]}
N 2890 -1690 2900 -1680 {lab=col[5]}
N 2900 -1680 2900 -1420 {lab=col[5]}
N 3220 -1730 3220 -1690 {lab=col_n[6]}
N 3240 -1730 3240 -1690 {lab=col[6]}
N 3230 -1680 3230 -1420 {lab=col_n[6]}
N 3220 -1690 3230 -1680 {lab=col_n[6]}
N 3240 -1690 3250 -1680 {lab=col[6]}
N 3250 -1680 3250 -1420 {lab=col[6]}
N 3580 -1730 3580 -1690 {lab=col_n[7]}
N 3600 -1730 3600 -1690 {lab=col[7]}
N 3590 -1680 3590 -1420 {lab=col_n[7]}
N 3580 -1690 3590 -1680 {lab=col_n[7]}
N 3600 -1690 3610 -1680 {lab=col[7]}
N 3610 -1680 3610 -1420 {lab=col[7]}
N 3910 -1730 3910 -1690 {lab=col_n[8]}
N 3930 -1730 3930 -1690 {lab=col[8]}
N 3920 -1680 3920 -1420 {lab=col_n[8]}
N 3910 -1690 3920 -1680 {lab=col_n[8]}
N 3930 -1690 3940 -1680 {lab=col[8]}
N 3940 -1680 3940 -1420 {lab=col[8]}
N 4590 -1730 4590 -1690 {lab=col_n[10]}
N 4610 -1730 4610 -1690 {lab=col[10]}
N 4600 -1680 4600 -1420 {lab=col_n[10]}
N 4590 -1690 4600 -1680 {lab=col_n[10]}
N 4610 -1690 4620 -1680 {lab=col[10]}
N 4620 -1680 4620 -1420 {lab=col[10]}
N 4940 -1730 4940 -1690 {lab=col_n[11]}
N 4960 -1730 4960 -1690 {lab=col[11]}
N 4950 -1680 4950 -1420 {lab=col_n[11]}
N 4940 -1690 4950 -1680 {lab=col_n[11]}
N 4960 -1690 4970 -1680 {lab=col[11]}
N 4970 -1680 4970 -1420 {lab=col[11]}
N 5280 -1730 5280 -1690 {lab=col_n[12]}
N 5300 -1730 5300 -1690 {lab=col[12]}
N 5290 -1680 5290 -1420 {lab=col_n[12]}
N 5280 -1690 5290 -1680 {lab=col_n[12]}
N 5300 -1690 5310 -1680 {lab=col[12]}
N 5310 -1680 5310 -1420 {lab=col[12]}
N 5620 -1730 5620 -1690 {lab=VDD}
N 5640 -1730 5640 -1690 {lab=VSS}
N 5630 -1680 5630 -1420 {lab=VDD}
N 5620 -1690 5630 -1680 {lab=VDD}
N 5640 -1690 5650 -1680 {lab=VSS}
N 5650 -1680 5650 -1420 {lab=VSS}
N 5640 -1410 5650 -1420 {lab=VSS}
N 5620 -1410 5630 -1420 {lab=VDD}
N 5300 -1410 5310 -1420 {lab=col[12]}
N 5280 -1410 5290 -1420 {lab=col_n[12]}
N 4960 -1410 4970 -1420 {lab=col[11]}
N 4940 -1410 4950 -1420 {lab=col_n[11]}
N 4610 -1410 4620 -1420 {lab=col[10]}
N 4590 -1410 4600 -1420 {lab=col_n[10]}
N 4240 -1730 4240 -1690 {lab=col_n[9]}
N 4260 -1730 4260 -1690 {lab=col[9]}
N 4250 -1680 4250 -1420 {lab=col_n[9]}
N 4240 -1690 4250 -1680 {lab=col_n[9]}
N 4260 -1690 4270 -1680 {lab=col[9]}
N 4270 -1680 4270 -1420 {lab=col[9]}
N 4260 -1410 4270 -1420 {lab=col[9]}
N 4240 -1410 4250 -1420 {lab=col_n[9]}
N 3930 -1410 3940 -1420 {lab=col[8]}
N 3910 -1410 3920 -1420 {lab=col_n[8]}
N 3600 -1410 3610 -1420 {lab=col[7]}
N 3580 -1410 3590 -1420 {lab=col_n[7]}
N 3240 -1410 3250 -1420 {lab=col[6]}
N 3220 -1410 3230 -1420 {lab=col_n[6]}
N 2890 -1410 2900 -1420 {lab=col[5]}
N 2870 -1410 2880 -1420 {lab=col_n[5]}
N 2550 -1410 2560 -1420 {lab=col[4]}
N 2530 -1410 2540 -1420 {lab=col_n[4]}
N 1150 -1410 1160 -1420 {lab=col_n[0]}
N 1170 -1410 1180 -1420 {lab=col[0]}
N 1480 -1410 1490 -1420 {lab=col_n[1]}
N 1500 -1410 1510 -1420 {lab=col[1]}
N 1830 -1410 1840 -1420 {lab=col_n[2]}
N 1850 -1410 1860 -1420 {lab=col[2]}
N 2180 -1410 2190 -1420 {lab=col_n[3]}
N 2200 -1410 2210 -1420 {lab=col[3]}
N 750 -2410 750 -2400 {
lab=VSS}
N 1070 -2410 1070 -2400 {
lab=VSS}
N 1400 -2410 1400 -2400 {
lab=VSS}
N 1750 -2410 1750 -2400 {
lab=VSS}
N 2100 -2410 2100 -2400 {
lab=VSS}
N 2450 -2410 2450 -2400 {
lab=VSS}
N 2790 -2410 2790 -2400 {
lab=VSS}
N 3140 -2410 3140 -2400 {
lab=VSS}
N 3500 -2410 3500 -2400 {
lab=VSS}
N 3830 -2410 3830 -2400 {
lab=VSS}
N 4160 -2410 4160 -2400 {
lab=VSS}
N 4510 -2410 4510 -2400 {
lab=VSS}
N 4860 -2410 4860 -2400 {
lab=VSS}
N 5200 -2410 5200 -2400 {
lab=VSS}
N 5540 -2410 5540 -2400 {
lab=VSS}
N 5560 -2650 5560 -2630 {
lab=vcm}
N 5540 -2640 5540 -2630 {
lab=VDD}
N 5600 -2650 5600 -2630 {
lab=ctop}
N 4880 -2650 4880 -2630 {
lab=vcm}
N 4860 -2640 4860 -2630 {
lab=VDD}
N 4920 -2650 4920 -2630 {
lab=ctop}
N 5220 -2650 5220 -2630 {
lab=vcm}
N 5200 -2640 5200 -2630 {
lab=VDD}
N 5260 -2650 5260 -2630 {
lab=ctop}
N 4530 -2650 4530 -2630 {
lab=vcm}
N 4510 -2640 4510 -2630 {
lab=VDD}
N 4570 -2650 4570 -2630 {
lab=ctop}
N 4180 -2650 4180 -2630 {
lab=vcm}
N 4160 -2640 4160 -2630 {
lab=VDD}
N 4220 -2650 4220 -2630 {
lab=ctop}
N 3850 -2650 3850 -2630 {
lab=vcm}
N 3830 -2640 3830 -2630 {
lab=VDD}
N 3890 -2650 3890 -2630 {
lab=ctop}
N 3520 -2650 3520 -2630 {
lab=vcm}
N 3500 -2640 3500 -2630 {
lab=VDD}
N 3560 -2650 3560 -2630 {
lab=ctop}
N 3160 -2650 3160 -2630 {
lab=vcm}
N 3140 -2640 3140 -2630 {
lab=VDD}
N 3200 -2650 3200 -2630 {
lab=ctop}
N 2810 -2650 2810 -2630 {
lab=vcm}
N 2790 -2640 2790 -2630 {
lab=VDD}
N 2850 -2650 2850 -2630 {
lab=ctop}
N 2470 -2650 2470 -2630 {
lab=vcm}
N 2450 -2640 2450 -2630 {
lab=VDD}
N 2510 -2650 2510 -2630 {
lab=ctop}
N 2120 -2650 2120 -2630 {
lab=vcm}
N 2100 -2640 2100 -2630 {
lab=VDD}
N 2160 -2650 2160 -2630 {
lab=ctop}
N 1770 -2650 1770 -2630 {
lab=vcm}
N 1750 -2640 1750 -2630 {
lab=VDD}
N 1810 -2650 1810 -2630 {
lab=ctop}
N 1420 -2650 1420 -2630 {
lab=vcm}
N 1400 -2640 1400 -2630 {
lab=VDD}
N 1460 -2650 1460 -2630 {
lab=ctop}
N 1090 -2650 1090 -2630 {
lab=vcm}
N 1070 -2640 1070 -2630 {
lab=VDD}
N 1130 -2650 1130 -2630 {
lab=ctop}
N 770 -2650 770 -2630 {
lab=vcm}
N 750 -2640 750 -2630 {
lab=VDD}
N 810 -2650 810 -2630 {
lab=ctop}
N 690 -2490 710 -2490 {
lab=sample_n}
N 690 -2510 710 -2510 {
lab=sample}
N 690 -2530 710 -2530 {
lab=rowon_n[5]}
N 690 -2550 710 -2550 {
lab=row_n[5]}
N 690 -2570 710 -2570 {
lab=rowoff_n[5]}
N 930 -2510 1030 -2510 {lab=#net9}
N 930 -2490 1030 -2490 {lab=#net10}
N 710 -2570 720 -2580 {lab=rowoff_n[5]}
N 720 -2580 940 -2580 {lab=rowoff_n[5]}
N 940 -2580 950 -2570 {lab=rowoff_n[5]}
N 950 -2570 1030 -2570 {lab=rowoff_n[5]}
N 710 -2550 720 -2560 {lab=row_n[5]}
N 720 -2560 940 -2560 {lab=row_n[5]}
N 940 -2560 950 -2550 {lab=row_n[5]}
N 950 -2550 1030 -2550 {lab=row_n[5]}
N 710 -2530 720 -2540 {lab=rowon_n[5]}
N 720 -2540 940 -2540 {lab=rowon_n[5]}
N 940 -2540 950 -2530 {lab=rowon_n[5]}
N 950 -2530 1030 -2530 {lab=rowon_n[5]}
N 1030 -2570 1040 -2580 {lab=rowoff_n[5]}
N 1030 -2550 1040 -2560 {lab=row_n[5]}
N 1040 -2560 1240 -2560 {lab=row_n[5]}
N 1240 -2560 1250 -2550 {lab=row_n[5]}
N 1250 -2550 1360 -2550 {lab=row_n[5]}
N 1040 -2580 1240 -2580 {lab=rowoff_n[5]}
N 1240 -2580 1250 -2570 {lab=rowoff_n[5]}
N 1250 -2570 1360 -2570 {lab=rowoff_n[5]}
N 1030 -2530 1040 -2540 {lab=rowon_n[5]}
N 1040 -2540 1240 -2540 {lab=rowon_n[5]}
N 1240 -2540 1250 -2530 {lab=rowon_n[5]}
N 1250 -2530 1360 -2530 {lab=rowon_n[5]}
N 1030 -2510 1040 -2520 {lab=#net9}
N 1040 -2520 1240 -2520 {lab=#net9}
N 1240 -2520 1250 -2510 {lab=#net9}
N 1250 -2510 1360 -2510 {lab=#net9}
N 1030 -2490 1040 -2500 {lab=#net10}
N 1040 -2500 1240 -2500 {lab=#net10}
N 1240 -2500 1250 -2490 {lab=#net10}
N 1250 -2490 1360 -2490 {lab=#net10}
N 1360 -2550 1370 -2560 {lab=row_n[5]}
N 1370 -2560 1570 -2560 {lab=row_n[5]}
N 1570 -2560 1580 -2550 {lab=row_n[5]}
N 1580 -2550 1710 -2550 {lab=row_n[5]}
N 1360 -2530 1370 -2540 {lab=rowon_n[5]}
N 1370 -2540 1570 -2540 {lab=rowon_n[5]}
N 1570 -2540 1580 -2530 {lab=rowon_n[5]}
N 1580 -2530 1710 -2530 {lab=rowon_n[5]}
N 1360 -2510 1370 -2520 {lab=#net9}
N 1370 -2520 1570 -2520 {lab=#net9}
N 1570 -2520 1580 -2510 {lab=#net9}
N 1580 -2510 1710 -2510 {lab=#net9}
N 1360 -2490 1380 -2500 {lab=#net10}
N 1380 -2500 1570 -2500 {lab=#net10}
N 1570 -2500 1580 -2490 {lab=#net10}
N 1580 -2490 1710 -2490 {lab=#net10}
N 1360 -2570 1370 -2580 {lab=rowoff_n[5]}
N 1370 -2580 1570 -2580 {lab=rowoff_n[5]}
N 1570 -2580 1580 -2570 {lab=rowoff_n[5]}
N 1580 -2570 1710 -2570 {lab=rowoff_n[5]}
N 1710 -2570 1720 -2580 {lab=rowoff_n[5]}
N 1720 -2580 1920 -2580 {lab=rowoff_n[5]}
N 1920 -2580 1930 -2570 {lab=rowoff_n[5]}
N 1930 -2570 2060 -2570 {lab=rowoff_n[5]}
N 1710 -2550 1720 -2560 {lab=row_n[5]}
N 1720 -2560 1920 -2560 {lab=row_n[5]}
N 1920 -2560 1930 -2550 {lab=row_n[5]}
N 1930 -2550 2060 -2550 {lab=row_n[5]}
N 1710 -2530 1720 -2540 {lab=rowon_n[5]}
N 1720 -2540 1920 -2540 {lab=rowon_n[5]}
N 1920 -2540 1930 -2530 {lab=rowon_n[5]}
N 1930 -2530 2060 -2530 {lab=rowon_n[5]}
N 1710 -2510 1720 -2520 {lab=#net9}
N 1720 -2520 1920 -2520 {lab=#net9}
N 1920 -2520 1930 -2510 {lab=#net9}
N 1930 -2510 2060 -2510 {lab=#net9}
N 1710 -2490 1720 -2500 {lab=#net10}
N 1720 -2500 1920 -2500 {lab=#net10}
N 1920 -2500 1930 -2490 {lab=#net10}
N 1930 -2490 2060 -2490 {lab=#net10}
N 2060 -2570 2070 -2580 {lab=rowoff_n[5]}
N 2070 -2580 2270 -2580 {lab=rowoff_n[5]}
N 2270 -2580 2280 -2570 {lab=rowoff_n[5]}
N 2280 -2570 2410 -2570 {lab=rowoff_n[5]}
N 2060 -2550 2070 -2560 {lab=row_n[5]}
N 2070 -2560 2270 -2560 {lab=row_n[5]}
N 2270 -2560 2280 -2550 {lab=row_n[5]}
N 2280 -2550 2410 -2550 {lab=row_n[5]}
N 2060 -2530 2070 -2540 {lab=rowon_n[5]}
N 2070 -2540 2270 -2540 {lab=rowon_n[5]}
N 2270 -2540 2280 -2530 {lab=rowon_n[5]}
N 2280 -2530 2410 -2530 {lab=rowon_n[5]}
N 2270 -2520 2280 -2510 {lab=#net9}
N 2280 -2510 2410 -2510 {lab=#net9}
N 2060 -2490 2070 -2500 {lab=#net10}
N 2070 -2500 2270 -2500 {lab=#net10}
N 2270 -2500 2280 -2490 {lab=#net10}
N 2280 -2490 2410 -2490 {lab=#net10}
N 2060 -2510 2070 -2520 {lab=#net9}
N 2070 -2520 2270 -2520 {lab=#net9}
N 2410 -2570 2420 -2580 {lab=rowoff_n[5]}
N 2420 -2580 2620 -2580 {lab=rowoff_n[5]}
N 2620 -2580 2630 -2570 {lab=rowoff_n[5]}
N 2630 -2570 2750 -2570 {lab=rowoff_n[5]}
N 2410 -2550 2420 -2560 {lab=row_n[5]}
N 2420 -2560 2620 -2560 {lab=row_n[5]}
N 2620 -2560 2630 -2550 {lab=row_n[5]}
N 2630 -2550 2750 -2550 {lab=row_n[5]}
N 2410 -2530 2420 -2540 {lab=rowon_n[5]}
N 2420 -2540 2620 -2540 {lab=rowon_n[5]}
N 2620 -2540 2630 -2530 {lab=rowon_n[5]}
N 2630 -2530 2750 -2530 {lab=rowon_n[5]}
N 2410 -2510 2420 -2520 {lab=#net9}
N 2420 -2520 2620 -2520 {lab=#net9}
N 2620 -2520 2630 -2510 {lab=#net9}
N 2630 -2510 2750 -2510 {lab=#net9}
N 2410 -2490 2420 -2500 {lab=#net10}
N 2420 -2500 2620 -2500 {lab=#net10}
N 2620 -2500 2630 -2490 {lab=#net10}
N 2630 -2490 2750 -2490 {lab=#net10}
N 2750 -2570 2760 -2580 {lab=rowoff_n[5]}
N 2760 -2580 2960 -2580 {lab=rowoff_n[5]}
N 2960 -2580 2970 -2570 {lab=rowoff_n[5]}
N 2970 -2570 3100 -2570 {lab=rowoff_n[5]}
N 2750 -2550 2760 -2560 {lab=row_n[5]}
N 2760 -2560 2960 -2560 {lab=row_n[5]}
N 2960 -2560 2970 -2550 {lab=row_n[5]}
N 2970 -2550 3100 -2550 {lab=row_n[5]}
N 2750 -2530 2760 -2540 {lab=rowon_n[5]}
N 2760 -2540 2960 -2540 {lab=rowon_n[5]}
N 2960 -2540 2970 -2530 {lab=rowon_n[5]}
N 2970 -2530 3100 -2530 {lab=rowon_n[5]}
N 2750 -2510 2760 -2520 {lab=#net9}
N 2760 -2520 2960 -2520 {lab=#net9}
N 2750 -2490 2760 -2500 {lab=#net10}
N 2760 -2500 2960 -2500 {lab=#net10}
N 2960 -2500 2970 -2490 {lab=#net10}
N 2970 -2490 3100 -2490 {lab=#net10}
N 2960 -2520 2970 -2510 {lab=#net9}
N 2970 -2510 3100 -2510 {lab=#net9}
N 3100 -2570 3110 -2580 {lab=rowoff_n[5]}
N 3110 -2580 3310 -2580 {lab=rowoff_n[5]}
N 3310 -2580 3320 -2570 {lab=rowoff_n[5]}
N 3320 -2570 3460 -2570 {lab=rowoff_n[5]}
N 3100 -2550 3110 -2560 {lab=row_n[5]}
N 3110 -2560 3310 -2560 {lab=row_n[5]}
N 3310 -2560 3320 -2550 {lab=row_n[5]}
N 3320 -2550 3460 -2550 {lab=row_n[5]}
N 3100 -2530 3110 -2540 {lab=rowon_n[5]}
N 3110 -2540 3310 -2540 {lab=rowon_n[5]}
N 3310 -2540 3320 -2530 {lab=rowon_n[5]}
N 3320 -2530 3460 -2530 {lab=rowon_n[5]}
N 3100 -2510 3110 -2520 {lab=#net9}
N 3110 -2520 3310 -2520 {lab=#net9}
N 3310 -2520 3320 -2510 {lab=#net9}
N 3320 -2510 3460 -2510 {lab=#net9}
N 3100 -2490 3110 -2500 {lab=#net10}
N 3110 -2500 3310 -2500 {lab=#net10}
N 3310 -2500 3320 -2490 {lab=#net10}
N 3320 -2490 3460 -2490 {lab=#net10}
N 3460 -2570 3470 -2580 {lab=rowoff_n[5]}
N 3470 -2580 3670 -2580 {lab=rowoff_n[5]}
N 3670 -2580 3680 -2570 {lab=rowoff_n[5]}
N 3680 -2570 3790 -2570 {lab=rowoff_n[5]}
N 3460 -2550 3470 -2560 {lab=row_n[5]}
N 3470 -2560 3670 -2560 {lab=row_n[5]}
N 3670 -2560 3680 -2550 {lab=row_n[5]}
N 3680 -2550 3790 -2550 {lab=row_n[5]}
N 3460 -2530 3470 -2540 {lab=rowon_n[5]}
N 3470 -2540 3670 -2540 {lab=rowon_n[5]}
N 3670 -2540 3680 -2530 {lab=rowon_n[5]}
N 3680 -2530 3790 -2530 {lab=rowon_n[5]}
N 3460 -2510 3470 -2520 {lab=#net9}
N 3470 -2520 3670 -2520 {lab=#net9}
N 3670 -2520 3680 -2510 {lab=#net9}
N 3680 -2510 3790 -2510 {lab=#net9}
N 3460 -2490 3470 -2500 {lab=#net10}
N 3470 -2500 3670 -2500 {lab=#net10}
N 3670 -2500 3680 -2490 {lab=#net10}
N 3680 -2490 3790 -2490 {lab=#net10}
N 3790 -2570 3800 -2580 {lab=rowoff_n[5]}
N 3800 -2580 4000 -2580 {lab=rowoff_n[5]}
N 4000 -2580 4010 -2570 {lab=rowoff_n[5]}
N 4010 -2570 4120 -2570 {lab=rowoff_n[5]}
N 3790 -2550 3800 -2560 {lab=row_n[5]}
N 3800 -2560 4000 -2560 {lab=row_n[5]}
N 4000 -2560 4010 -2550 {lab=row_n[5]}
N 4010 -2550 4120 -2550 {lab=row_n[5]}
N 3790 -2530 3800 -2540 {lab=rowon_n[5]}
N 3800 -2540 4000 -2540 {lab=rowon_n[5]}
N 4000 -2540 4010 -2530 {lab=rowon_n[5]}
N 4010 -2530 4120 -2530 {lab=rowon_n[5]}
N 3790 -2510 3800 -2520 {lab=#net9}
N 3800 -2520 4000 -2520 {lab=#net9}
N 4000 -2520 4010 -2510 {lab=#net9}
N 4010 -2510 4120 -2510 {lab=#net9}
N 3790 -2490 3800 -2500 {lab=#net10}
N 3800 -2500 4000 -2500 {lab=#net10}
N 4000 -2500 4020 -2490 {lab=#net10}
N 4020 -2490 4120 -2490 {lab=#net10}
N 4120 -2570 4130 -2580 {lab=rowoff_n[5]}
N 4130 -2580 4330 -2580 {lab=rowoff_n[5]}
N 4330 -2580 4340 -2570 {lab=rowoff_n[5]}
N 4340 -2570 4470 -2570 {lab=rowoff_n[5]}
N 4120 -2550 4130 -2560 {lab=row_n[5]}
N 4130 -2560 4330 -2560 {lab=row_n[5]}
N 4330 -2560 4340 -2550 {lab=row_n[5]}
N 4340 -2550 4470 -2550 {lab=row_n[5]}
N 4120 -2530 4130 -2540 {lab=rowon_n[5]}
N 4130 -2540 4330 -2540 {lab=rowon_n[5]}
N 4330 -2540 4340 -2530 {lab=rowon_n[5]}
N 4340 -2530 4470 -2530 {lab=rowon_n[5]}
N 4120 -2510 4130 -2520 {lab=#net9}
N 4130 -2520 4330 -2520 {lab=#net9}
N 4330 -2520 4340 -2510 {lab=#net9}
N 4340 -2510 4470 -2510 {lab=#net9}
N 4120 -2490 4130 -2500 {lab=#net10}
N 4130 -2500 4330 -2500 {lab=#net10}
N 4330 -2500 4340 -2490 {lab=#net10}
N 4340 -2490 4470 -2490 {lab=#net10}
N 4470 -2570 4480 -2580 {lab=rowoff_n[5]}
N 4480 -2580 4680 -2580 {lab=rowoff_n[5]}
N 4680 -2580 4690 -2570 {lab=rowoff_n[5]}
N 4690 -2570 4820 -2570 {lab=rowoff_n[5]}
N 4470 -2550 4480 -2560 {lab=row_n[5]}
N 4480 -2560 4680 -2560 {lab=row_n[5]}
N 4470 -2530 4480 -2540 {lab=rowon_n[5]}
N 4480 -2540 4680 -2540 {lab=rowon_n[5]}
N 4680 -2540 4690 -2530 {lab=rowon_n[5]}
N 4690 -2530 4820 -2530 {lab=rowon_n[5]}
N 4680 -2560 4690 -2550 {lab=row_n[5]}
N 4690 -2550 4820 -2550 {lab=row_n[5]}
N 4470 -2510 4480 -2520 {lab=#net9}
N 4480 -2520 4680 -2520 {lab=#net9}
N 4680 -2520 4690 -2510 {lab=#net9}
N 4690 -2510 4820 -2510 {lab=#net9}
N 4470 -2490 4480 -2500 {lab=#net10}
N 4480 -2500 4680 -2500 {lab=#net10}
N 4680 -2500 4690 -2490 {lab=#net10}
N 4690 -2490 4820 -2490 {lab=#net10}
N 4820 -2570 4830 -2580 {lab=rowoff_n[5]}
N 4830 -2580 5030 -2580 {lab=rowoff_n[5]}
N 5030 -2580 5040 -2570 {lab=rowoff_n[5]}
N 5040 -2570 5160 -2570 {lab=rowoff_n[5]}
N 4820 -2550 4830 -2560 {lab=row_n[5]}
N 4830 -2560 5030 -2560 {lab=row_n[5]}
N 5030 -2560 5040 -2550 {lab=row_n[5]}
N 5040 -2550 5160 -2550 {lab=row_n[5]}
N 4820 -2530 4830 -2540 {lab=rowon_n[5]}
N 4830 -2540 5030 -2540 {lab=rowon_n[5]}
N 5030 -2540 5040 -2530 {lab=rowon_n[5]}
N 5040 -2530 5160 -2530 {lab=rowon_n[5]}
N 4820 -2510 4830 -2520 {lab=#net9}
N 4830 -2520 5030 -2520 {lab=#net9}
N 5030 -2520 5040 -2510 {lab=#net9}
N 5040 -2510 5160 -2510 {lab=#net9}
N 4820 -2490 4830 -2500 {lab=#net10}
N 4830 -2500 5030 -2500 {lab=#net10}
N 5030 -2500 5040 -2490 {lab=#net10}
N 5040 -2490 5160 -2490 {lab=#net10}
N 5160 -2570 5170 -2580 {lab=rowoff_n[5]}
N 5170 -2580 5370 -2580 {lab=rowoff_n[5]}
N 5370 -2580 5380 -2570 {lab=rowoff_n[5]}
N 5380 -2570 5500 -2570 {lab=rowoff_n[5]}
N 5160 -2550 5170 -2560 {lab=row_n[5]}
N 5170 -2560 5370 -2560 {lab=row_n[5]}
N 5370 -2560 5380 -2550 {lab=row_n[5]}
N 5380 -2550 5500 -2550 {lab=row_n[5]}
N 5160 -2530 5170 -2540 {lab=rowon_n[5]}
N 5170 -2540 5370 -2540 {lab=rowon_n[5]}
N 5370 -2540 5380 -2530 {lab=rowon_n[5]}
N 5380 -2530 5500 -2530 {lab=rowon_n[5]}
N 5160 -2510 5170 -2520 {lab=#net9}
N 5170 -2520 5370 -2520 {lab=#net9}
N 5370 -2520 5380 -2510 {lab=#net9}
N 5380 -2510 5500 -2510 {lab=#net9}
N 5160 -2490 5170 -2500 {lab=#net10}
N 5170 -2500 5370 -2500 {lab=#net10}
N 5370 -2500 5390 -2490 {lab=#net10}
N 5390 -2490 5500 -2490 {lab=#net10}
N 5500 -2570 5510 -2580 {lab=rowoff_n[5]}
N 5510 -2580 5710 -2580 {lab=rowoff_n[5]}
N 5500 -2550 5510 -2560 {lab=row_n[5]}
N 5510 -2560 5710 -2560 {lab=row_n[5]}
N 5710 -2560 5720 -2550 {lab=row_n[5]}
N 5710 -2580 5720 -2570 {lab=rowoff_n[5]}
N 5500 -2530 5510 -2540 {lab=rowon_n[5]}
N 5510 -2540 5710 -2540 {lab=rowon_n[5]}
N 5500 -2510 5510 -2520 {lab=#net9}
N 5510 -2520 5710 -2520 {lab=#net9}
N 5710 -2520 5720 -2510 {lab=#net9}
N 5500 -2490 5510 -2500 {lab=#net10}
N 5510 -2500 5710 -2500 {lab=#net10}
N 5710 -2500 5720 -2490 {lab=#net10}
N 5710 -2540 5720 -2530 {lab=rowon_n[5]}
N 750 -2740 750 -2730 {
lab=VSS}
N 1070 -2740 1070 -2730 {
lab=VSS}
N 1400 -2740 1400 -2730 {
lab=VSS}
N 1750 -2740 1750 -2730 {
lab=VSS}
N 2100 -2740 2100 -2730 {
lab=VSS}
N 2450 -2740 2450 -2730 {
lab=VSS}
N 2790 -2740 2790 -2730 {
lab=VSS}
N 3140 -2740 3140 -2730 {
lab=VSS}
N 3500 -2740 3500 -2730 {
lab=VSS}
N 3830 -2740 3830 -2730 {
lab=VSS}
N 4160 -2740 4160 -2730 {
lab=VSS}
N 4510 -2740 4510 -2730 {
lab=VSS}
N 4860 -2740 4860 -2730 {
lab=VSS}
N 5200 -2740 5200 -2730 {
lab=VSS}
N 5540 -2740 5540 -2730 {
lab=VSS}
N 5560 -2980 5560 -2960 {
lab=vcm}
N 5540 -2970 5540 -2960 {
lab=VDD}
N 5600 -2980 5600 -2960 {
lab=ctop}
N 4880 -2980 4880 -2960 {
lab=vcm}
N 4860 -2970 4860 -2960 {
lab=VDD}
N 4920 -2980 4920 -2960 {
lab=ctop}
N 5220 -2980 5220 -2960 {
lab=vcm}
N 5200 -2970 5200 -2960 {
lab=VDD}
N 5260 -2980 5260 -2960 {
lab=ctop}
N 4530 -2980 4530 -2960 {
lab=vcm}
N 4510 -2970 4510 -2960 {
lab=VDD}
N 4570 -2980 4570 -2960 {
lab=ctop}
N 4180 -2980 4180 -2960 {
lab=vcm}
N 4160 -2970 4160 -2960 {
lab=VDD}
N 4220 -2980 4220 -2960 {
lab=ctop}
N 3850 -2980 3850 -2960 {
lab=vcm}
N 3830 -2970 3830 -2960 {
lab=VDD}
N 3890 -2980 3890 -2960 {
lab=ctop}
N 3520 -2980 3520 -2960 {
lab=vcm}
N 3500 -2970 3500 -2960 {
lab=VDD}
N 3560 -2980 3560 -2960 {
lab=ctop}
N 3160 -2980 3160 -2960 {
lab=vcm}
N 3140 -2970 3140 -2960 {
lab=VDD}
N 3200 -2980 3200 -2960 {
lab=ctop}
N 2810 -2980 2810 -2960 {
lab=vcm}
N 2790 -2970 2790 -2960 {
lab=VDD}
N 2850 -2980 2850 -2960 {
lab=ctop}
N 2470 -2980 2470 -2960 {
lab=vcm}
N 2450 -2970 2450 -2960 {
lab=VDD}
N 2510 -2980 2510 -2960 {
lab=ctop}
N 2120 -2980 2120 -2960 {
lab=vcm}
N 2100 -2970 2100 -2960 {
lab=VDD}
N 2160 -2980 2160 -2960 {
lab=ctop}
N 1770 -2980 1770 -2960 {
lab=vcm}
N 1750 -2970 1750 -2960 {
lab=VDD}
N 1810 -2980 1810 -2960 {
lab=ctop}
N 1420 -2980 1420 -2960 {
lab=vcm}
N 1400 -2970 1400 -2960 {
lab=VDD}
N 1460 -2980 1460 -2960 {
lab=ctop}
N 1090 -2980 1090 -2960 {
lab=vcm}
N 1070 -2970 1070 -2960 {
lab=VDD}
N 1130 -2980 1130 -2960 {
lab=ctop}
N 770 -2980 770 -2960 {
lab=vcm}
N 750 -2970 750 -2960 {
lab=VDD}
N 810 -2980 810 -2960 {
lab=ctop}
N 690 -2820 710 -2820 {
lab=sample_n}
N 690 -2840 710 -2840 {
lab=sample}
N 690 -2860 710 -2860 {
lab=rowon_n[6]}
N 690 -2880 710 -2880 {
lab=row_n[6]}
N 690 -2900 710 -2900 {
lab=rowoff_n[6]}
N 930 -2840 1030 -2840 {lab=#net11}
N 930 -2820 1030 -2820 {lab=#net12}
N 710 -2900 720 -2910 {lab=rowoff_n[6]}
N 720 -2910 940 -2910 {lab=rowoff_n[6]}
N 940 -2910 950 -2900 {lab=rowoff_n[6]}
N 950 -2900 1030 -2900 {lab=rowoff_n[6]}
N 710 -2880 720 -2890 {lab=row_n[6]}
N 720 -2890 940 -2890 {lab=row_n[6]}
N 940 -2890 950 -2880 {lab=row_n[6]}
N 950 -2880 1030 -2880 {lab=row_n[6]}
N 710 -2860 720 -2870 {lab=rowon_n[6]}
N 720 -2870 940 -2870 {lab=rowon_n[6]}
N 940 -2870 950 -2860 {lab=rowon_n[6]}
N 950 -2860 1030 -2860 {lab=rowon_n[6]}
N 1030 -2900 1040 -2910 {lab=rowoff_n[6]}
N 1030 -2880 1040 -2890 {lab=row_n[6]}
N 1040 -2890 1240 -2890 {lab=row_n[6]}
N 1240 -2890 1250 -2880 {lab=row_n[6]}
N 1250 -2880 1360 -2880 {lab=row_n[6]}
N 1040 -2910 1240 -2910 {lab=rowoff_n[6]}
N 1240 -2910 1250 -2900 {lab=rowoff_n[6]}
N 1250 -2900 1360 -2900 {lab=rowoff_n[6]}
N 1030 -2860 1040 -2870 {lab=rowon_n[6]}
N 1040 -2870 1240 -2870 {lab=rowon_n[6]}
N 1240 -2870 1250 -2860 {lab=rowon_n[6]}
N 1250 -2860 1360 -2860 {lab=rowon_n[6]}
N 1030 -2840 1040 -2850 {lab=#net11}
N 1040 -2850 1240 -2850 {lab=#net11}
N 1240 -2850 1250 -2840 {lab=#net11}
N 1250 -2840 1360 -2840 {lab=#net11}
N 1030 -2820 1040 -2830 {lab=#net12}
N 1040 -2830 1240 -2830 {lab=#net12}
N 1240 -2830 1250 -2820 {lab=#net12}
N 1250 -2820 1360 -2820 {lab=#net12}
N 1360 -2880 1370 -2890 {lab=row_n[6]}
N 1370 -2890 1570 -2890 {lab=row_n[6]}
N 1570 -2890 1580 -2880 {lab=row_n[6]}
N 1580 -2880 1710 -2880 {lab=row_n[6]}
N 1360 -2860 1370 -2870 {lab=rowon_n[6]}
N 1370 -2870 1570 -2870 {lab=rowon_n[6]}
N 1570 -2870 1580 -2860 {lab=rowon_n[6]}
N 1580 -2860 1710 -2860 {lab=rowon_n[6]}
N 1360 -2840 1370 -2850 {lab=#net11}
N 1370 -2850 1570 -2850 {lab=#net11}
N 1570 -2850 1580 -2840 {lab=#net11}
N 1580 -2840 1710 -2840 {lab=#net11}
N 1360 -2820 1380 -2830 {lab=#net12}
N 1380 -2830 1570 -2830 {lab=#net12}
N 1570 -2830 1580 -2820 {lab=#net12}
N 1580 -2820 1710 -2820 {lab=#net12}
N 1360 -2900 1370 -2910 {lab=rowoff_n[6]}
N 1370 -2910 1570 -2910 {lab=rowoff_n[6]}
N 1570 -2910 1580 -2900 {lab=rowoff_n[6]}
N 1580 -2900 1710 -2900 {lab=rowoff_n[6]}
N 1710 -2900 1720 -2910 {lab=rowoff_n[6]}
N 1720 -2910 1920 -2910 {lab=rowoff_n[6]}
N 1920 -2910 1930 -2900 {lab=rowoff_n[6]}
N 1930 -2900 2060 -2900 {lab=rowoff_n[6]}
N 1710 -2880 1720 -2890 {lab=row_n[6]}
N 1720 -2890 1920 -2890 {lab=row_n[6]}
N 1920 -2890 1930 -2880 {lab=row_n[6]}
N 1930 -2880 2060 -2880 {lab=row_n[6]}
N 1710 -2860 1720 -2870 {lab=rowon_n[6]}
N 1720 -2870 1920 -2870 {lab=rowon_n[6]}
N 1920 -2870 1930 -2860 {lab=rowon_n[6]}
N 1930 -2860 2060 -2860 {lab=rowon_n[6]}
N 1710 -2840 1720 -2850 {lab=#net11}
N 1720 -2850 1920 -2850 {lab=#net11}
N 1920 -2850 1930 -2840 {lab=#net11}
N 1930 -2840 2060 -2840 {lab=#net11}
N 1710 -2820 1720 -2830 {lab=#net12}
N 1720 -2830 1920 -2830 {lab=#net12}
N 1920 -2830 1930 -2820 {lab=#net12}
N 1930 -2820 2060 -2820 {lab=#net12}
N 2060 -2900 2070 -2910 {lab=rowoff_n[6]}
N 2070 -2910 2270 -2910 {lab=rowoff_n[6]}
N 2270 -2910 2280 -2900 {lab=rowoff_n[6]}
N 2280 -2900 2410 -2900 {lab=rowoff_n[6]}
N 2060 -2880 2070 -2890 {lab=row_n[6]}
N 2070 -2890 2270 -2890 {lab=row_n[6]}
N 2270 -2890 2280 -2880 {lab=row_n[6]}
N 2280 -2880 2410 -2880 {lab=row_n[6]}
N 2060 -2860 2070 -2870 {lab=rowon_n[6]}
N 2070 -2870 2270 -2870 {lab=rowon_n[6]}
N 2270 -2870 2280 -2860 {lab=rowon_n[6]}
N 2280 -2860 2410 -2860 {lab=rowon_n[6]}
N 2270 -2850 2280 -2840 {lab=#net11}
N 2280 -2840 2410 -2840 {lab=#net11}
N 2060 -2820 2070 -2830 {lab=#net12}
N 2070 -2830 2270 -2830 {lab=#net12}
N 2270 -2830 2280 -2820 {lab=#net12}
N 2280 -2820 2410 -2820 {lab=#net12}
N 2060 -2840 2070 -2850 {lab=#net11}
N 2070 -2850 2270 -2850 {lab=#net11}
N 2410 -2900 2420 -2910 {lab=rowoff_n[6]}
N 2420 -2910 2620 -2910 {lab=rowoff_n[6]}
N 2620 -2910 2630 -2900 {lab=rowoff_n[6]}
N 2630 -2900 2750 -2900 {lab=rowoff_n[6]}
N 2410 -2880 2420 -2890 {lab=row_n[6]}
N 2420 -2890 2620 -2890 {lab=row_n[6]}
N 2620 -2890 2630 -2880 {lab=row_n[6]}
N 2630 -2880 2750 -2880 {lab=row_n[6]}
N 2410 -2860 2420 -2870 {lab=rowon_n[6]}
N 2420 -2870 2620 -2870 {lab=rowon_n[6]}
N 2620 -2870 2630 -2860 {lab=rowon_n[6]}
N 2630 -2860 2750 -2860 {lab=rowon_n[6]}
N 2410 -2840 2420 -2850 {lab=#net11}
N 2420 -2850 2620 -2850 {lab=#net11}
N 2620 -2850 2630 -2840 {lab=#net11}
N 2630 -2840 2750 -2840 {lab=#net11}
N 2410 -2820 2420 -2830 {lab=#net12}
N 2420 -2830 2620 -2830 {lab=#net12}
N 2620 -2830 2630 -2820 {lab=#net12}
N 2630 -2820 2750 -2820 {lab=#net12}
N 2750 -2900 2760 -2910 {lab=rowoff_n[6]}
N 2760 -2910 2960 -2910 {lab=rowoff_n[6]}
N 2960 -2910 2970 -2900 {lab=rowoff_n[6]}
N 2970 -2900 3100 -2900 {lab=rowoff_n[6]}
N 2750 -2880 2760 -2890 {lab=row_n[6]}
N 2760 -2890 2960 -2890 {lab=row_n[6]}
N 2960 -2890 2970 -2880 {lab=row_n[6]}
N 2970 -2880 3100 -2880 {lab=row_n[6]}
N 2750 -2860 2760 -2870 {lab=rowon_n[6]}
N 2760 -2870 2960 -2870 {lab=rowon_n[6]}
N 2960 -2870 2970 -2860 {lab=rowon_n[6]}
N 2970 -2860 3100 -2860 {lab=rowon_n[6]}
N 2750 -2840 2760 -2850 {lab=#net11}
N 2760 -2850 2960 -2850 {lab=#net11}
N 2750 -2820 2760 -2830 {lab=#net12}
N 2760 -2830 2960 -2830 {lab=#net12}
N 2960 -2830 2970 -2820 {lab=#net12}
N 2970 -2820 3100 -2820 {lab=#net12}
N 2960 -2850 2970 -2840 {lab=#net11}
N 2970 -2840 3100 -2840 {lab=#net11}
N 3100 -2900 3110 -2910 {lab=rowoff_n[6]}
N 3110 -2910 3310 -2910 {lab=rowoff_n[6]}
N 3310 -2910 3320 -2900 {lab=rowoff_n[6]}
N 3320 -2900 3460 -2900 {lab=rowoff_n[6]}
N 3100 -2880 3110 -2890 {lab=row_n[6]}
N 3110 -2890 3310 -2890 {lab=row_n[6]}
N 3310 -2890 3320 -2880 {lab=row_n[6]}
N 3320 -2880 3460 -2880 {lab=row_n[6]}
N 3100 -2860 3110 -2870 {lab=rowon_n[6]}
N 3110 -2870 3310 -2870 {lab=rowon_n[6]}
N 3310 -2870 3320 -2860 {lab=rowon_n[6]}
N 3320 -2860 3460 -2860 {lab=rowon_n[6]}
N 3100 -2840 3110 -2850 {lab=#net11}
N 3110 -2850 3310 -2850 {lab=#net11}
N 3310 -2850 3320 -2840 {lab=#net11}
N 3320 -2840 3460 -2840 {lab=#net11}
N 3100 -2820 3110 -2830 {lab=#net12}
N 3110 -2830 3310 -2830 {lab=#net12}
N 3310 -2830 3320 -2820 {lab=#net12}
N 3320 -2820 3460 -2820 {lab=#net12}
N 3460 -2900 3470 -2910 {lab=rowoff_n[6]}
N 3470 -2910 3670 -2910 {lab=rowoff_n[6]}
N 3670 -2910 3680 -2900 {lab=rowoff_n[6]}
N 3680 -2900 3790 -2900 {lab=rowoff_n[6]}
N 3460 -2880 3470 -2890 {lab=row_n[6]}
N 3470 -2890 3670 -2890 {lab=row_n[6]}
N 3670 -2890 3680 -2880 {lab=row_n[6]}
N 3680 -2880 3790 -2880 {lab=row_n[6]}
N 3460 -2860 3470 -2870 {lab=rowon_n[6]}
N 3470 -2870 3670 -2870 {lab=rowon_n[6]}
N 3670 -2870 3680 -2860 {lab=rowon_n[6]}
N 3680 -2860 3790 -2860 {lab=rowon_n[6]}
N 3460 -2840 3470 -2850 {lab=#net11}
N 3470 -2850 3670 -2850 {lab=#net11}
N 3670 -2850 3680 -2840 {lab=#net11}
N 3680 -2840 3790 -2840 {lab=#net11}
N 3460 -2820 3470 -2830 {lab=#net12}
N 3470 -2830 3670 -2830 {lab=#net12}
N 3670 -2830 3680 -2820 {lab=#net12}
N 3680 -2820 3790 -2820 {lab=#net12}
N 3790 -2900 3800 -2910 {lab=rowoff_n[6]}
N 3800 -2910 4000 -2910 {lab=rowoff_n[6]}
N 4000 -2910 4010 -2900 {lab=rowoff_n[6]}
N 4010 -2900 4120 -2900 {lab=rowoff_n[6]}
N 3790 -2880 3800 -2890 {lab=row_n[6]}
N 3800 -2890 4000 -2890 {lab=row_n[6]}
N 4000 -2890 4010 -2880 {lab=row_n[6]}
N 4010 -2880 4120 -2880 {lab=row_n[6]}
N 3790 -2860 3800 -2870 {lab=rowon_n[6]}
N 3800 -2870 4000 -2870 {lab=rowon_n[6]}
N 4000 -2870 4010 -2860 {lab=rowon_n[6]}
N 4010 -2860 4120 -2860 {lab=rowon_n[6]}
N 3790 -2840 3800 -2850 {lab=#net11}
N 3800 -2850 4000 -2850 {lab=#net11}
N 4000 -2850 4010 -2840 {lab=#net11}
N 4010 -2840 4120 -2840 {lab=#net11}
N 3790 -2820 3800 -2830 {lab=#net12}
N 3800 -2830 4000 -2830 {lab=#net12}
N 4000 -2830 4020 -2820 {lab=#net12}
N 4020 -2820 4120 -2820 {lab=#net12}
N 4120 -2900 4130 -2910 {lab=rowoff_n[6]}
N 4130 -2910 4330 -2910 {lab=rowoff_n[6]}
N 4330 -2910 4340 -2900 {lab=rowoff_n[6]}
N 4340 -2900 4470 -2900 {lab=rowoff_n[6]}
N 4120 -2880 4130 -2890 {lab=row_n[6]}
N 4130 -2890 4330 -2890 {lab=row_n[6]}
N 4330 -2890 4340 -2880 {lab=row_n[6]}
N 4340 -2880 4470 -2880 {lab=row_n[6]}
N 4120 -2860 4130 -2870 {lab=rowon_n[6]}
N 4130 -2870 4330 -2870 {lab=rowon_n[6]}
N 4330 -2870 4340 -2860 {lab=rowon_n[6]}
N 4340 -2860 4470 -2860 {lab=rowon_n[6]}
N 4120 -2840 4130 -2850 {lab=#net11}
N 4130 -2850 4330 -2850 {lab=#net11}
N 4330 -2850 4340 -2840 {lab=#net11}
N 4340 -2840 4470 -2840 {lab=#net11}
N 4120 -2820 4130 -2830 {lab=#net12}
N 4130 -2830 4330 -2830 {lab=#net12}
N 4330 -2830 4340 -2820 {lab=#net12}
N 4340 -2820 4470 -2820 {lab=#net12}
N 4470 -2900 4480 -2910 {lab=rowoff_n[6]}
N 4480 -2910 4680 -2910 {lab=rowoff_n[6]}
N 4680 -2910 4690 -2900 {lab=rowoff_n[6]}
N 4690 -2900 4820 -2900 {lab=rowoff_n[6]}
N 4470 -2880 4480 -2890 {lab=row_n[6]}
N 4480 -2890 4680 -2890 {lab=row_n[6]}
N 4470 -2860 4480 -2870 {lab=rowon_n[6]}
N 4480 -2870 4680 -2870 {lab=rowon_n[6]}
N 4680 -2870 4690 -2860 {lab=rowon_n[6]}
N 4690 -2860 4820 -2860 {lab=rowon_n[6]}
N 4680 -2890 4690 -2880 {lab=row_n[6]}
N 4690 -2880 4820 -2880 {lab=row_n[6]}
N 4470 -2840 4480 -2850 {lab=#net11}
N 4480 -2850 4680 -2850 {lab=#net11}
N 4680 -2850 4690 -2840 {lab=#net11}
N 4690 -2840 4820 -2840 {lab=#net11}
N 4470 -2820 4480 -2830 {lab=#net12}
N 4480 -2830 4680 -2830 {lab=#net12}
N 4680 -2830 4690 -2820 {lab=#net12}
N 4690 -2820 4820 -2820 {lab=#net12}
N 4820 -2900 4830 -2910 {lab=rowoff_n[6]}
N 4830 -2910 5030 -2910 {lab=rowoff_n[6]}
N 5030 -2910 5040 -2900 {lab=rowoff_n[6]}
N 5040 -2900 5160 -2900 {lab=rowoff_n[6]}
N 4820 -2880 4830 -2890 {lab=row_n[6]}
N 4830 -2890 5030 -2890 {lab=row_n[6]}
N 5030 -2890 5040 -2880 {lab=row_n[6]}
N 5040 -2880 5160 -2880 {lab=row_n[6]}
N 4820 -2860 4830 -2870 {lab=rowon_n[6]}
N 4830 -2870 5030 -2870 {lab=rowon_n[6]}
N 5030 -2870 5040 -2860 {lab=rowon_n[6]}
N 5040 -2860 5160 -2860 {lab=rowon_n[6]}
N 4820 -2840 4830 -2850 {lab=#net11}
N 4830 -2850 5030 -2850 {lab=#net11}
N 5030 -2850 5040 -2840 {lab=#net11}
N 5040 -2840 5160 -2840 {lab=#net11}
N 4820 -2820 4830 -2830 {lab=#net12}
N 4830 -2830 5030 -2830 {lab=#net12}
N 5030 -2830 5040 -2820 {lab=#net12}
N 5040 -2820 5160 -2820 {lab=#net12}
N 5160 -2900 5170 -2910 {lab=rowoff_n[6]}
N 5170 -2910 5370 -2910 {lab=rowoff_n[6]}
N 5370 -2910 5380 -2900 {lab=rowoff_n[6]}
N 5380 -2900 5500 -2900 {lab=rowoff_n[6]}
N 5160 -2880 5170 -2890 {lab=row_n[6]}
N 5170 -2890 5370 -2890 {lab=row_n[6]}
N 5370 -2890 5380 -2880 {lab=row_n[6]}
N 5380 -2880 5500 -2880 {lab=row_n[6]}
N 5160 -2860 5170 -2870 {lab=rowon_n[6]}
N 5170 -2870 5370 -2870 {lab=rowon_n[6]}
N 5370 -2870 5380 -2860 {lab=rowon_n[6]}
N 5380 -2860 5500 -2860 {lab=rowon_n[6]}
N 5160 -2840 5170 -2850 {lab=#net11}
N 5170 -2850 5370 -2850 {lab=#net11}
N 5370 -2850 5380 -2840 {lab=#net11}
N 5380 -2840 5500 -2840 {lab=#net11}
N 5160 -2820 5170 -2830 {lab=#net12}
N 5170 -2830 5370 -2830 {lab=#net12}
N 5370 -2830 5390 -2820 {lab=#net12}
N 5390 -2820 5500 -2820 {lab=#net12}
N 5500 -2900 5510 -2910 {lab=rowoff_n[6]}
N 5510 -2910 5710 -2910 {lab=rowoff_n[6]}
N 5500 -2880 5510 -2890 {lab=row_n[6]}
N 5510 -2890 5710 -2890 {lab=row_n[6]}
N 5710 -2890 5720 -2880 {lab=row_n[6]}
N 5710 -2910 5720 -2900 {lab=rowoff_n[6]}
N 5500 -2860 5510 -2870 {lab=rowon_n[6]}
N 5510 -2870 5710 -2870 {lab=rowon_n[6]}
N 5500 -2840 5510 -2850 {lab=#net11}
N 5510 -2850 5710 -2850 {lab=#net11}
N 5710 -2850 5720 -2840 {lab=#net11}
N 5500 -2820 5510 -2830 {lab=#net12}
N 5510 -2830 5710 -2830 {lab=#net12}
N 5710 -2830 5720 -2820 {lab=#net12}
N 5710 -2870 5720 -2860 {lab=rowon_n[6]}
N 830 -2410 840 -2420 {lab=VDD}
N 840 -2670 840 -2420 {lab=VDD}
N 830 -2680 840 -2670 {lab=VDD}
N 830 -2740 830 -2680 {lab=VDD}
N 850 -2740 850 -2680 {lab=VSS}
N 850 -2680 860 -2670 {lab=VSS}
N 860 -2670 860 -2420 {lab=VSS}
N 850 -2410 860 -2420 {lab=VSS}
N 1160 -2670 1160 -2420 {lab=col_n[0]}
N 1150 -2680 1160 -2670 {lab=col_n[0]}
N 1150 -2740 1150 -2680 {lab=col_n[0]}
N 1170 -2740 1170 -2680 {lab=col[0]}
N 1170 -2680 1180 -2670 {lab=col[0]}
N 1180 -2670 1180 -2420 {lab=col[0]}
N 1490 -2670 1490 -2420 {lab=col_n[1]}
N 1480 -2680 1490 -2670 {lab=col_n[1]}
N 1480 -2740 1480 -2680 {lab=col_n[1]}
N 1500 -2740 1500 -2680 {lab=col[1]}
N 1500 -2680 1510 -2670 {lab=col[1]}
N 1510 -2670 1510 -2420 {lab=col[1]}
N 1840 -2670 1840 -2420 {lab=col_n[2]}
N 1830 -2680 1840 -2670 {lab=col_n[2]}
N 1830 -2740 1830 -2680 {lab=col_n[2]}
N 1850 -2740 1850 -2680 {lab=col[2]}
N 1850 -2680 1860 -2670 {lab=col[2]}
N 1860 -2670 1860 -2420 {lab=col[2]}
N 2190 -2670 2190 -2420 {lab=col_n[3]}
N 2180 -2680 2190 -2670 {lab=col_n[3]}
N 2180 -2740 2180 -2680 {lab=col_n[3]}
N 2200 -2740 2200 -2680 {lab=col[3]}
N 2200 -2680 2210 -2670 {lab=col[3]}
N 2210 -2670 2210 -2420 {lab=col[3]}
N 2540 -2670 2540 -2420 {lab=col_n[4]}
N 2530 -2680 2540 -2670 {lab=col_n[4]}
N 2530 -2740 2530 -2680 {lab=col_n[4]}
N 2550 -2740 2550 -2680 {lab=col[4]}
N 2550 -2680 2560 -2670 {lab=col[4]}
N 2560 -2670 2560 -2420 {lab=col[4]}
N 2880 -2670 2880 -2420 {lab=col_n[5]}
N 2870 -2680 2880 -2670 {lab=col_n[5]}
N 2870 -2740 2870 -2680 {lab=col_n[5]}
N 2890 -2740 2890 -2680 {lab=col[5]}
N 2890 -2680 2900 -2670 {lab=col[5]}
N 2900 -2670 2900 -2420 {lab=col[5]}
N 3230 -2670 3230 -2420 {lab=col_n[6]}
N 3220 -2680 3230 -2670 {lab=col_n[6]}
N 3220 -2740 3220 -2680 {lab=col_n[6]}
N 3240 -2740 3240 -2680 {lab=col[6]}
N 3240 -2680 3250 -2670 {lab=col[6]}
N 3250 -2670 3250 -2420 {lab=col[6]}
N 3590 -2670 3590 -2420 {lab=col_n[7]}
N 3580 -2680 3590 -2670 {lab=col_n[7]}
N 3580 -2740 3580 -2680 {lab=col_n[7]}
N 3600 -2740 3600 -2680 {lab=col[7]}
N 3600 -2680 3610 -2670 {lab=col[7]}
N 3610 -2670 3610 -2420 {lab=col[7]}
N 3920 -2670 3920 -2420 {lab=col_n[8]}
N 3910 -2680 3920 -2670 {lab=col_n[8]}
N 3910 -2740 3910 -2680 {lab=col_n[8]}
N 3930 -2740 3930 -2680 {lab=col[8]}
N 3930 -2680 3940 -2670 {lab=col[8]}
N 3940 -2670 3940 -2420 {lab=col[8]}
N 4250 -2670 4250 -2420 {lab=col_n[9]}
N 4240 -2680 4250 -2670 {lab=col_n[9]}
N 4240 -2740 4240 -2680 {lab=col_n[9]}
N 4260 -2740 4260 -2680 {lab=col[9]}
N 4260 -2680 4270 -2670 {lab=col[9]}
N 4270 -2670 4270 -2420 {lab=col[9]}
N 4600 -2670 4600 -2420 {lab=col_n[10]}
N 4590 -2680 4600 -2670 {lab=col_n[10]}
N 4590 -2740 4590 -2680 {lab=col_n[10]}
N 4610 -2740 4610 -2680 {lab=col[10]}
N 4610 -2680 4620 -2670 {lab=col[10]}
N 4620 -2670 4620 -2420 {lab=col[10]}
N 4950 -2670 4950 -2420 {lab=col_n[11]}
N 4940 -2680 4950 -2670 {lab=col_n[11]}
N 4940 -2740 4940 -2680 {lab=col_n[11]}
N 4960 -2740 4960 -2680 {lab=col[11]}
N 4960 -2680 4970 -2670 {lab=col[11]}
N 4970 -2670 4970 -2420 {lab=col[11]}
N 5290 -2670 5290 -2420 {lab=col_n[12]}
N 5280 -2680 5290 -2670 {lab=col_n[12]}
N 5280 -2740 5280 -2680 {lab=col_n[12]}
N 5300 -2740 5300 -2680 {lab=col[12]}
N 5300 -2680 5310 -2670 {lab=col[12]}
N 5310 -2670 5310 -2420 {lab=col[12]}
N 5630 -2670 5630 -2420 {lab=VDD}
N 5620 -2680 5630 -2670 {lab=VDD}
N 5620 -2740 5620 -2680 {lab=VDD}
N 5640 -2740 5640 -2680 {lab=VSS}
N 5640 -2680 5650 -2670 {lab=VSS}
N 5650 -2670 5650 -2420 {lab=VSS}
N 5640 -2410 5650 -2420 {lab=VSS}
N 5620 -2410 5630 -2420 {lab=VDD}
N 5280 -2410 5290 -2420 {lab=col_n[12]}
N 5300 -2410 5310 -2420 {lab=col[12]}
N 4940 -2410 4950 -2420 {lab=col_n[11]}
N 4960 -2410 4970 -2420 {lab=col[11]}
N 4590 -2410 4600 -2420 {lab=col_n[10]}
N 4610 -2410 4620 -2420 {lab=col[10]}
N 4260 -2410 4270 -2420 {lab=col[9]}
N 4240 -2410 4250 -2420 {lab=col_n[9]}
N 3930 -2410 3940 -2420 {lab=col[8]}
N 3910 -2410 3920 -2420 {lab=col_n[8]}
N 3580 -2410 3590 -2420 {lab=col_n[7]}
N 3600 -2410 3610 -2420 {lab=col[7]}
N 3220 -2410 3230 -2420 {lab=col_n[6]}
N 3240 -2410 3250 -2420 {lab=col[6]}
N 2890 -2410 2900 -2420 {lab=col[5]}
N 2870 -2410 2880 -2420 {lab=col_n[5]}
N 2550 -2410 2560 -2420 {lab=col[4]}
N 2530 -2410 2540 -2420 {lab=col_n[4]}
N 2200 -2410 2210 -2420 {lab=col[3]}
N 2180 -2410 2190 -2420 {lab=col_n[3]}
N 1850 -2410 1860 -2420 {lab=col[2]}
N 1830 -2410 1840 -2420 {lab=col_n[2]}
N 1500 -2410 1510 -2420 {lab=col[1]}
N 1480 -2410 1490 -2420 {lab=col_n[1]}
N 1150 -2410 1160 -2420 {lab=col_n[0]}
N 1170 -2410 1180 -2420 {lab=col[0]}
N 830 -2410 830 -2370 {lab=VDD}
N 850 -2410 850 -2370 {lab=VSS}
N 750 -3060 750 -3050 {
lab=VSS}
N 1070 -3060 1070 -3050 {
lab=VSS}
N 1400 -3060 1400 -3050 {
lab=VSS}
N 1750 -3060 1750 -3050 {
lab=VSS}
N 2100 -3060 2100 -3050 {
lab=VSS}
N 2450 -3060 2450 -3050 {
lab=VSS}
N 2790 -3060 2790 -3050 {
lab=VSS}
N 3140 -3060 3140 -3050 {
lab=VSS}
N 3500 -3060 3500 -3050 {
lab=VSS}
N 3830 -3060 3830 -3050 {
lab=VSS}
N 4160 -3060 4160 -3050 {
lab=VSS}
N 4510 -3060 4510 -3050 {
lab=VSS}
N 4860 -3060 4860 -3050 {
lab=VSS}
N 5200 -3060 5200 -3050 {
lab=VSS}
N 5540 -3060 5540 -3050 {
lab=VSS}
N 5560 -3300 5560 -3280 {
lab=vcm}
N 5540 -3290 5540 -3280 {
lab=VDD}
N 5600 -3300 5600 -3280 {
lab=ctop}
N 4880 -3300 4880 -3280 {
lab=vcm}
N 4860 -3290 4860 -3280 {
lab=VDD}
N 4920 -3300 4920 -3280 {
lab=ctop}
N 5220 -3300 5220 -3280 {
lab=vcm}
N 5200 -3290 5200 -3280 {
lab=VDD}
N 5260 -3300 5260 -3280 {
lab=ctop}
N 4530 -3300 4530 -3280 {
lab=vcm}
N 4510 -3290 4510 -3280 {
lab=VDD}
N 4570 -3300 4570 -3280 {
lab=ctop}
N 4180 -3300 4180 -3280 {
lab=vcm}
N 4160 -3290 4160 -3280 {
lab=VDD}
N 4220 -3300 4220 -3280 {
lab=ctop}
N 3850 -3300 3850 -3280 {
lab=vcm}
N 3830 -3290 3830 -3280 {
lab=VDD}
N 3890 -3300 3890 -3280 {
lab=ctop}
N 3520 -3300 3520 -3280 {
lab=vcm}
N 3500 -3290 3500 -3280 {
lab=VDD}
N 3560 -3300 3560 -3280 {
lab=ctop}
N 3160 -3300 3160 -3280 {
lab=vcm}
N 3140 -3290 3140 -3280 {
lab=VDD}
N 3200 -3300 3200 -3280 {
lab=ctop}
N 2810 -3300 2810 -3280 {
lab=vcm}
N 2790 -3290 2790 -3280 {
lab=VDD}
N 2850 -3300 2850 -3280 {
lab=ctop}
N 2470 -3300 2470 -3280 {
lab=vcm}
N 2450 -3290 2450 -3280 {
lab=VDD}
N 2510 -3300 2510 -3280 {
lab=ctop}
N 2120 -3300 2120 -3280 {
lab=vcm}
N 2100 -3290 2100 -3280 {
lab=VDD}
N 2160 -3300 2160 -3280 {
lab=ctop}
N 1770 -3300 1770 -3280 {
lab=vcm}
N 1750 -3290 1750 -3280 {
lab=VDD}
N 1810 -3300 1810 -3280 {
lab=ctop}
N 1420 -3300 1420 -3280 {
lab=vcm}
N 1400 -3290 1400 -3280 {
lab=VDD}
N 1460 -3300 1460 -3280 {
lab=ctop}
N 1090 -3300 1090 -3280 {
lab=vcm}
N 1070 -3290 1070 -3280 {
lab=VDD}
N 1130 -3300 1130 -3280 {
lab=ctop}
N 770 -3300 770 -3280 {
lab=vcm}
N 750 -3290 750 -3280 {
lab=VDD}
N 810 -3300 810 -3280 {
lab=ctop}
N 690 -3140 710 -3140 {
lab=sample_n}
N 690 -3160 710 -3160 {
lab=sample}
N 690 -3180 710 -3180 {
lab=rowon_n[7]}
N 690 -3200 710 -3200 {
lab=row_n[7]}
N 690 -3220 710 -3220 {
lab=rowoff_n[7]}
N 930 -3160 1030 -3160 {lab=#net13}
N 930 -3140 1030 -3140 {lab=#net14}
N 710 -3220 720 -3230 {lab=rowoff_n[7]}
N 720 -3230 940 -3230 {lab=rowoff_n[7]}
N 940 -3230 950 -3220 {lab=rowoff_n[7]}
N 950 -3220 1030 -3220 {lab=rowoff_n[7]}
N 710 -3200 720 -3210 {lab=row_n[7]}
N 720 -3210 940 -3210 {lab=row_n[7]}
N 940 -3210 950 -3200 {lab=row_n[7]}
N 950 -3200 1030 -3200 {lab=row_n[7]}
N 710 -3180 720 -3190 {lab=rowon_n[7]}
N 720 -3190 940 -3190 {lab=rowon_n[7]}
N 940 -3190 950 -3180 {lab=rowon_n[7]}
N 950 -3180 1030 -3180 {lab=rowon_n[7]}
N 1030 -3220 1040 -3230 {lab=rowoff_n[7]}
N 1030 -3200 1040 -3210 {lab=row_n[7]}
N 1040 -3210 1240 -3210 {lab=row_n[7]}
N 1240 -3210 1250 -3200 {lab=row_n[7]}
N 1250 -3200 1360 -3200 {lab=row_n[7]}
N 1040 -3230 1240 -3230 {lab=rowoff_n[7]}
N 1240 -3230 1250 -3220 {lab=rowoff_n[7]}
N 1250 -3220 1360 -3220 {lab=rowoff_n[7]}
N 1030 -3180 1040 -3190 {lab=rowon_n[7]}
N 1040 -3190 1240 -3190 {lab=rowon_n[7]}
N 1240 -3190 1250 -3180 {lab=rowon_n[7]}
N 1250 -3180 1360 -3180 {lab=rowon_n[7]}
N 1030 -3160 1040 -3170 {lab=#net13}
N 1040 -3170 1240 -3170 {lab=#net13}
N 1240 -3170 1250 -3160 {lab=#net13}
N 1250 -3160 1360 -3160 {lab=#net13}
N 1030 -3140 1040 -3150 {lab=#net14}
N 1040 -3150 1240 -3150 {lab=#net14}
N 1240 -3150 1250 -3140 {lab=#net14}
N 1250 -3140 1360 -3140 {lab=#net14}
N 1360 -3200 1370 -3210 {lab=row_n[7]}
N 1370 -3210 1570 -3210 {lab=row_n[7]}
N 1570 -3210 1580 -3200 {lab=row_n[7]}
N 1580 -3200 1710 -3200 {lab=row_n[7]}
N 1360 -3180 1370 -3190 {lab=rowon_n[7]}
N 1370 -3190 1570 -3190 {lab=rowon_n[7]}
N 1570 -3190 1580 -3180 {lab=rowon_n[7]}
N 1580 -3180 1710 -3180 {lab=rowon_n[7]}
N 1360 -3160 1370 -3170 {lab=#net13}
N 1370 -3170 1570 -3170 {lab=#net13}
N 1570 -3170 1580 -3160 {lab=#net13}
N 1580 -3160 1710 -3160 {lab=#net13}
N 1360 -3140 1380 -3150 {lab=#net14}
N 1380 -3150 1570 -3150 {lab=#net14}
N 1570 -3150 1580 -3140 {lab=#net14}
N 1580 -3140 1710 -3140 {lab=#net14}
N 1360 -3220 1370 -3230 {lab=rowoff_n[7]}
N 1370 -3230 1570 -3230 {lab=rowoff_n[7]}
N 1570 -3230 1580 -3220 {lab=rowoff_n[7]}
N 1580 -3220 1710 -3220 {lab=rowoff_n[7]}
N 1710 -3220 1720 -3230 {lab=rowoff_n[7]}
N 1720 -3230 1920 -3230 {lab=rowoff_n[7]}
N 1920 -3230 1930 -3220 {lab=rowoff_n[7]}
N 1930 -3220 2060 -3220 {lab=rowoff_n[7]}
N 1710 -3200 1720 -3210 {lab=row_n[7]}
N 1720 -3210 1920 -3210 {lab=row_n[7]}
N 1920 -3210 1930 -3200 {lab=row_n[7]}
N 1930 -3200 2060 -3200 {lab=row_n[7]}
N 1710 -3180 1720 -3190 {lab=rowon_n[7]}
N 1720 -3190 1920 -3190 {lab=rowon_n[7]}
N 1920 -3190 1930 -3180 {lab=rowon_n[7]}
N 1930 -3180 2060 -3180 {lab=rowon_n[7]}
N 1710 -3160 1720 -3170 {lab=#net13}
N 1720 -3170 1920 -3170 {lab=#net13}
N 1920 -3170 1930 -3160 {lab=#net13}
N 1930 -3160 2060 -3160 {lab=#net13}
N 1710 -3140 1720 -3150 {lab=#net14}
N 1720 -3150 1920 -3150 {lab=#net14}
N 1920 -3150 1930 -3140 {lab=#net14}
N 1930 -3140 2060 -3140 {lab=#net14}
N 2060 -3220 2070 -3230 {lab=rowoff_n[7]}
N 2070 -3230 2270 -3230 {lab=rowoff_n[7]}
N 2270 -3230 2280 -3220 {lab=rowoff_n[7]}
N 2280 -3220 2410 -3220 {lab=rowoff_n[7]}
N 2060 -3200 2070 -3210 {lab=row_n[7]}
N 2070 -3210 2270 -3210 {lab=row_n[7]}
N 2270 -3210 2280 -3200 {lab=row_n[7]}
N 2280 -3200 2410 -3200 {lab=row_n[7]}
N 2060 -3180 2070 -3190 {lab=rowon_n[7]}
N 2070 -3190 2270 -3190 {lab=rowon_n[7]}
N 2270 -3190 2280 -3180 {lab=rowon_n[7]}
N 2280 -3180 2410 -3180 {lab=rowon_n[7]}
N 2270 -3170 2280 -3160 {lab=#net13}
N 2280 -3160 2410 -3160 {lab=#net13}
N 2060 -3140 2070 -3150 {lab=#net14}
N 2070 -3150 2270 -3150 {lab=#net14}
N 2270 -3150 2280 -3140 {lab=#net14}
N 2280 -3140 2410 -3140 {lab=#net14}
N 2060 -3160 2070 -3170 {lab=#net13}
N 2070 -3170 2270 -3170 {lab=#net13}
N 2410 -3220 2420 -3230 {lab=rowoff_n[7]}
N 2420 -3230 2620 -3230 {lab=rowoff_n[7]}
N 2620 -3230 2630 -3220 {lab=rowoff_n[7]}
N 2630 -3220 2750 -3220 {lab=rowoff_n[7]}
N 2410 -3200 2420 -3210 {lab=row_n[7]}
N 2420 -3210 2620 -3210 {lab=row_n[7]}
N 2620 -3210 2630 -3200 {lab=row_n[7]}
N 2630 -3200 2750 -3200 {lab=row_n[7]}
N 2410 -3180 2420 -3190 {lab=rowon_n[7]}
N 2420 -3190 2620 -3190 {lab=rowon_n[7]}
N 2620 -3190 2630 -3180 {lab=rowon_n[7]}
N 2630 -3180 2750 -3180 {lab=rowon_n[7]}
N 2410 -3160 2420 -3170 {lab=#net13}
N 2420 -3170 2620 -3170 {lab=#net13}
N 2620 -3170 2630 -3160 {lab=#net13}
N 2630 -3160 2750 -3160 {lab=#net13}
N 2410 -3140 2420 -3150 {lab=#net14}
N 2420 -3150 2620 -3150 {lab=#net14}
N 2620 -3150 2630 -3140 {lab=#net14}
N 2630 -3140 2750 -3140 {lab=#net14}
N 2750 -3220 2760 -3230 {lab=rowoff_n[7]}
N 2760 -3230 2960 -3230 {lab=rowoff_n[7]}
N 2960 -3230 2970 -3220 {lab=rowoff_n[7]}
N 2970 -3220 3100 -3220 {lab=rowoff_n[7]}
N 2750 -3200 2760 -3210 {lab=row_n[7]}
N 2760 -3210 2960 -3210 {lab=row_n[7]}
N 2960 -3210 2970 -3200 {lab=row_n[7]}
N 2970 -3200 3100 -3200 {lab=row_n[7]}
N 2750 -3180 2760 -3190 {lab=rowon_n[7]}
N 2760 -3190 2960 -3190 {lab=rowon_n[7]}
N 2960 -3190 2970 -3180 {lab=rowon_n[7]}
N 2970 -3180 3100 -3180 {lab=rowon_n[7]}
N 2750 -3160 2760 -3170 {lab=#net13}
N 2760 -3170 2960 -3170 {lab=#net13}
N 2750 -3140 2760 -3150 {lab=#net14}
N 2760 -3150 2960 -3150 {lab=#net14}
N 2960 -3150 2970 -3140 {lab=#net14}
N 2970 -3140 3100 -3140 {lab=#net14}
N 2960 -3170 2970 -3160 {lab=#net13}
N 2970 -3160 3100 -3160 {lab=#net13}
N 3100 -3220 3110 -3230 {lab=rowoff_n[7]}
N 3110 -3230 3310 -3230 {lab=rowoff_n[7]}
N 3310 -3230 3320 -3220 {lab=rowoff_n[7]}
N 3320 -3220 3460 -3220 {lab=rowoff_n[7]}
N 3100 -3200 3110 -3210 {lab=row_n[7]}
N 3110 -3210 3310 -3210 {lab=row_n[7]}
N 3310 -3210 3320 -3200 {lab=row_n[7]}
N 3320 -3200 3460 -3200 {lab=row_n[7]}
N 3100 -3180 3110 -3190 {lab=rowon_n[7]}
N 3110 -3190 3310 -3190 {lab=rowon_n[7]}
N 3310 -3190 3320 -3180 {lab=rowon_n[7]}
N 3320 -3180 3460 -3180 {lab=rowon_n[7]}
N 3100 -3160 3110 -3170 {lab=#net13}
N 3110 -3170 3310 -3170 {lab=#net13}
N 3310 -3170 3320 -3160 {lab=#net13}
N 3320 -3160 3460 -3160 {lab=#net13}
N 3100 -3140 3110 -3150 {lab=#net14}
N 3110 -3150 3310 -3150 {lab=#net14}
N 3310 -3150 3320 -3140 {lab=#net14}
N 3320 -3140 3460 -3140 {lab=#net14}
N 3460 -3220 3470 -3230 {lab=rowoff_n[7]}
N 3470 -3230 3670 -3230 {lab=rowoff_n[7]}
N 3670 -3230 3680 -3220 {lab=rowoff_n[7]}
N 3680 -3220 3790 -3220 {lab=rowoff_n[7]}
N 3460 -3200 3470 -3210 {lab=row_n[7]}
N 3470 -3210 3670 -3210 {lab=row_n[7]}
N 3670 -3210 3680 -3200 {lab=row_n[7]}
N 3680 -3200 3790 -3200 {lab=row_n[7]}
N 3460 -3180 3470 -3190 {lab=rowon_n[7]}
N 3470 -3190 3670 -3190 {lab=rowon_n[7]}
N 3670 -3190 3680 -3180 {lab=rowon_n[7]}
N 3680 -3180 3790 -3180 {lab=rowon_n[7]}
N 3460 -3160 3470 -3170 {lab=#net13}
N 3470 -3170 3670 -3170 {lab=#net13}
N 3670 -3170 3680 -3160 {lab=#net13}
N 3680 -3160 3790 -3160 {lab=#net13}
N 3460 -3140 3470 -3150 {lab=#net14}
N 3470 -3150 3670 -3150 {lab=#net14}
N 3670 -3150 3680 -3140 {lab=#net14}
N 3680 -3140 3790 -3140 {lab=#net14}
N 3790 -3220 3800 -3230 {lab=rowoff_n[7]}
N 3800 -3230 4000 -3230 {lab=rowoff_n[7]}
N 4000 -3230 4010 -3220 {lab=rowoff_n[7]}
N 4010 -3220 4120 -3220 {lab=rowoff_n[7]}
N 3790 -3200 3800 -3210 {lab=row_n[7]}
N 3800 -3210 4000 -3210 {lab=row_n[7]}
N 4000 -3210 4010 -3200 {lab=row_n[7]}
N 4010 -3200 4120 -3200 {lab=row_n[7]}
N 3790 -3180 3800 -3190 {lab=rowon_n[7]}
N 3800 -3190 4000 -3190 {lab=rowon_n[7]}
N 4000 -3190 4010 -3180 {lab=rowon_n[7]}
N 4010 -3180 4120 -3180 {lab=rowon_n[7]}
N 3790 -3160 3800 -3170 {lab=#net13}
N 3800 -3170 4000 -3170 {lab=#net13}
N 4000 -3170 4010 -3160 {lab=#net13}
N 4010 -3160 4120 -3160 {lab=#net13}
N 3790 -3140 3800 -3150 {lab=#net14}
N 3800 -3150 4000 -3150 {lab=#net14}
N 4000 -3150 4020 -3140 {lab=#net14}
N 4020 -3140 4120 -3140 {lab=#net14}
N 4120 -3220 4130 -3230 {lab=rowoff_n[7]}
N 4130 -3230 4330 -3230 {lab=rowoff_n[7]}
N 4330 -3230 4340 -3220 {lab=rowoff_n[7]}
N 4340 -3220 4470 -3220 {lab=rowoff_n[7]}
N 4120 -3200 4130 -3210 {lab=row_n[7]}
N 4130 -3210 4330 -3210 {lab=row_n[7]}
N 4330 -3210 4340 -3200 {lab=row_n[7]}
N 4340 -3200 4470 -3200 {lab=row_n[7]}
N 4120 -3180 4130 -3190 {lab=rowon_n[7]}
N 4130 -3190 4330 -3190 {lab=rowon_n[7]}
N 4330 -3190 4340 -3180 {lab=rowon_n[7]}
N 4340 -3180 4470 -3180 {lab=rowon_n[7]}
N 4120 -3160 4130 -3170 {lab=#net13}
N 4130 -3170 4330 -3170 {lab=#net13}
N 4330 -3170 4340 -3160 {lab=#net13}
N 4340 -3160 4470 -3160 {lab=#net13}
N 4120 -3140 4130 -3150 {lab=#net14}
N 4130 -3150 4330 -3150 {lab=#net14}
N 4330 -3150 4340 -3140 {lab=#net14}
N 4340 -3140 4470 -3140 {lab=#net14}
N 4470 -3220 4480 -3230 {lab=rowoff_n[7]}
N 4480 -3230 4680 -3230 {lab=rowoff_n[7]}
N 4680 -3230 4690 -3220 {lab=rowoff_n[7]}
N 4690 -3220 4820 -3220 {lab=rowoff_n[7]}
N 4470 -3200 4480 -3210 {lab=row_n[7]}
N 4480 -3210 4680 -3210 {lab=row_n[7]}
N 4470 -3180 4480 -3190 {lab=rowon_n[7]}
N 4480 -3190 4680 -3190 {lab=rowon_n[7]}
N 4680 -3190 4690 -3180 {lab=rowon_n[7]}
N 4690 -3180 4820 -3180 {lab=rowon_n[7]}
N 4680 -3210 4690 -3200 {lab=row_n[7]}
N 4690 -3200 4820 -3200 {lab=row_n[7]}
N 4470 -3160 4480 -3170 {lab=#net13}
N 4480 -3170 4680 -3170 {lab=#net13}
N 4680 -3170 4690 -3160 {lab=#net13}
N 4690 -3160 4820 -3160 {lab=#net13}
N 4470 -3140 4480 -3150 {lab=#net14}
N 4480 -3150 4680 -3150 {lab=#net14}
N 4680 -3150 4690 -3140 {lab=#net14}
N 4690 -3140 4820 -3140 {lab=#net14}
N 4820 -3220 4830 -3230 {lab=rowoff_n[7]}
N 4830 -3230 5030 -3230 {lab=rowoff_n[7]}
N 5030 -3230 5040 -3220 {lab=rowoff_n[7]}
N 5040 -3220 5160 -3220 {lab=rowoff_n[7]}
N 4820 -3200 4830 -3210 {lab=row_n[7]}
N 4830 -3210 5030 -3210 {lab=row_n[7]}
N 5030 -3210 5040 -3200 {lab=row_n[7]}
N 5040 -3200 5160 -3200 {lab=row_n[7]}
N 4820 -3180 4830 -3190 {lab=rowon_n[7]}
N 4830 -3190 5030 -3190 {lab=rowon_n[7]}
N 5030 -3190 5040 -3180 {lab=rowon_n[7]}
N 5040 -3180 5160 -3180 {lab=rowon_n[7]}
N 4820 -3160 4830 -3170 {lab=#net13}
N 4830 -3170 5030 -3170 {lab=#net13}
N 5030 -3170 5040 -3160 {lab=#net13}
N 5040 -3160 5160 -3160 {lab=#net13}
N 4820 -3140 4830 -3150 {lab=#net14}
N 4830 -3150 5030 -3150 {lab=#net14}
N 5030 -3150 5040 -3140 {lab=#net14}
N 5040 -3140 5160 -3140 {lab=#net14}
N 5160 -3220 5170 -3230 {lab=rowoff_n[7]}
N 5170 -3230 5370 -3230 {lab=rowoff_n[7]}
N 5370 -3230 5380 -3220 {lab=rowoff_n[7]}
N 5380 -3220 5500 -3220 {lab=rowoff_n[7]}
N 5160 -3200 5170 -3210 {lab=row_n[7]}
N 5170 -3210 5370 -3210 {lab=row_n[7]}
N 5370 -3210 5380 -3200 {lab=row_n[7]}
N 5380 -3200 5500 -3200 {lab=row_n[7]}
N 5160 -3180 5170 -3190 {lab=rowon_n[7]}
N 5170 -3190 5370 -3190 {lab=rowon_n[7]}
N 5370 -3190 5380 -3180 {lab=rowon_n[7]}
N 5380 -3180 5500 -3180 {lab=rowon_n[7]}
N 5160 -3160 5170 -3170 {lab=#net13}
N 5170 -3170 5370 -3170 {lab=#net13}
N 5370 -3170 5380 -3160 {lab=#net13}
N 5380 -3160 5500 -3160 {lab=#net13}
N 5160 -3140 5170 -3150 {lab=#net14}
N 5170 -3150 5370 -3150 {lab=#net14}
N 5370 -3150 5390 -3140 {lab=#net14}
N 5390 -3140 5500 -3140 {lab=#net14}
N 5500 -3220 5510 -3230 {lab=rowoff_n[7]}
N 5510 -3230 5710 -3230 {lab=rowoff_n[7]}
N 5500 -3200 5510 -3210 {lab=row_n[7]}
N 5510 -3210 5710 -3210 {lab=row_n[7]}
N 5710 -3210 5720 -3200 {lab=row_n[7]}
N 5710 -3230 5720 -3220 {lab=rowoff_n[7]}
N 5500 -3180 5510 -3190 {lab=rowon_n[7]}
N 5510 -3190 5710 -3190 {lab=rowon_n[7]}
N 5500 -3160 5510 -3170 {lab=#net13}
N 5510 -3170 5710 -3170 {lab=#net13}
N 5710 -3170 5720 -3160 {lab=#net13}
N 5500 -3140 5510 -3150 {lab=#net14}
N 5510 -3150 5710 -3150 {lab=#net14}
N 5710 -3150 5720 -3140 {lab=#net14}
N 5710 -3190 5720 -3180 {lab=rowon_n[7]}
N 750 -3390 750 -3380 {
lab=VSS}
N 1070 -3390 1070 -3380 {
lab=VSS}
N 1400 -3390 1400 -3380 {
lab=VSS}
N 1750 -3390 1750 -3380 {
lab=VSS}
N 2100 -3390 2100 -3380 {
lab=VSS}
N 2450 -3390 2450 -3380 {
lab=VSS}
N 2790 -3390 2790 -3380 {
lab=VSS}
N 3140 -3390 3140 -3380 {
lab=VSS}
N 3500 -3390 3500 -3380 {
lab=VSS}
N 3830 -3390 3830 -3380 {
lab=VSS}
N 4160 -3390 4160 -3380 {
lab=VSS}
N 4510 -3390 4510 -3380 {
lab=VSS}
N 4860 -3390 4860 -3380 {
lab=VSS}
N 5200 -3390 5200 -3380 {
lab=VSS}
N 5540 -3390 5540 -3380 {
lab=VSS}
N 5560 -3630 5560 -3610 {
lab=vcm}
N 5540 -3620 5540 -3610 {
lab=VDD}
N 5600 -3630 5600 -3610 {
lab=ctop}
N 4880 -3630 4880 -3610 {
lab=vcm}
N 4860 -3620 4860 -3610 {
lab=VDD}
N 4920 -3630 4920 -3610 {
lab=ctop}
N 5220 -3630 5220 -3610 {
lab=vcm}
N 5200 -3620 5200 -3610 {
lab=VDD}
N 5260 -3630 5260 -3610 {
lab=ctop}
N 4530 -3630 4530 -3610 {
lab=vcm}
N 4510 -3620 4510 -3610 {
lab=VDD}
N 4570 -3630 4570 -3610 {
lab=ctop}
N 4180 -3630 4180 -3610 {
lab=vcm}
N 4160 -3620 4160 -3610 {
lab=VDD}
N 4220 -3630 4220 -3610 {
lab=ctop}
N 3850 -3630 3850 -3610 {
lab=vcm}
N 3830 -3620 3830 -3610 {
lab=VDD}
N 3890 -3630 3890 -3610 {
lab=ctop}
N 3520 -3630 3520 -3610 {
lab=vcm}
N 3500 -3620 3500 -3610 {
lab=VDD}
N 3560 -3630 3560 -3610 {
lab=ctop}
N 3160 -3630 3160 -3610 {
lab=vcm}
N 3140 -3620 3140 -3610 {
lab=VDD}
N 3200 -3630 3200 -3610 {
lab=ctop}
N 2810 -3630 2810 -3610 {
lab=vcm}
N 2790 -3620 2790 -3610 {
lab=VDD}
N 2850 -3630 2850 -3610 {
lab=ctop}
N 2470 -3630 2470 -3610 {
lab=vcm}
N 2450 -3620 2450 -3610 {
lab=VDD}
N 2510 -3630 2510 -3610 {
lab=ctop}
N 2120 -3630 2120 -3610 {
lab=vcm}
N 2100 -3620 2100 -3610 {
lab=VDD}
N 2160 -3630 2160 -3610 {
lab=ctop}
N 1770 -3630 1770 -3610 {
lab=vcm}
N 1750 -3620 1750 -3610 {
lab=VDD}
N 1810 -3630 1810 -3610 {
lab=ctop}
N 1420 -3630 1420 -3610 {
lab=vcm}
N 1400 -3620 1400 -3610 {
lab=VDD}
N 1460 -3630 1460 -3610 {
lab=ctop}
N 1090 -3630 1090 -3610 {
lab=vcm}
N 1070 -3620 1070 -3610 {
lab=VDD}
N 1130 -3630 1130 -3610 {
lab=ctop}
N 770 -3630 770 -3610 {
lab=vcm}
N 750 -3620 750 -3610 {
lab=VDD}
N 810 -3630 810 -3610 {
lab=ctop}
N 690 -3470 710 -3470 {
lab=sample_n}
N 690 -3490 710 -3490 {
lab=sample}
N 690 -3510 710 -3510 {
lab=rowon_n[8]}
N 690 -3530 710 -3530 {
lab=row_n[8]}
N 690 -3550 710 -3550 {
lab=rowoff_n[8]}
N 930 -3490 1030 -3490 {lab=#net15}
N 930 -3470 1030 -3470 {lab=#net16}
N 710 -3550 720 -3560 {lab=rowoff_n[8]}
N 720 -3560 940 -3560 {lab=rowoff_n[8]}
N 940 -3560 950 -3550 {lab=rowoff_n[8]}
N 950 -3550 1030 -3550 {lab=rowoff_n[8]}
N 710 -3530 720 -3540 {lab=row_n[8]}
N 720 -3540 940 -3540 {lab=row_n[8]}
N 940 -3540 950 -3530 {lab=row_n[8]}
N 950 -3530 1030 -3530 {lab=row_n[8]}
N 710 -3510 720 -3520 {lab=rowon_n[8]}
N 720 -3520 940 -3520 {lab=rowon_n[8]}
N 940 -3520 950 -3510 {lab=rowon_n[8]}
N 950 -3510 1030 -3510 {lab=rowon_n[8]}
N 1030 -3550 1040 -3560 {lab=rowoff_n[8]}
N 1030 -3530 1040 -3540 {lab=row_n[8]}
N 1040 -3540 1240 -3540 {lab=row_n[8]}
N 1240 -3540 1250 -3530 {lab=row_n[8]}
N 1250 -3530 1360 -3530 {lab=row_n[8]}
N 1040 -3560 1240 -3560 {lab=rowoff_n[8]}
N 1240 -3560 1250 -3550 {lab=rowoff_n[8]}
N 1250 -3550 1360 -3550 {lab=rowoff_n[8]}
N 1030 -3510 1040 -3520 {lab=rowon_n[8]}
N 1040 -3520 1240 -3520 {lab=rowon_n[8]}
N 1240 -3520 1250 -3510 {lab=rowon_n[8]}
N 1250 -3510 1360 -3510 {lab=rowon_n[8]}
N 1030 -3490 1040 -3500 {lab=#net15}
N 1040 -3500 1240 -3500 {lab=#net15}
N 1240 -3500 1250 -3490 {lab=#net15}
N 1250 -3490 1360 -3490 {lab=#net15}
N 1030 -3470 1040 -3480 {lab=#net16}
N 1040 -3480 1240 -3480 {lab=#net16}
N 1240 -3480 1250 -3470 {lab=#net16}
N 1250 -3470 1360 -3470 {lab=#net16}
N 1360 -3530 1370 -3540 {lab=row_n[8]}
N 1370 -3540 1570 -3540 {lab=row_n[8]}
N 1570 -3540 1580 -3530 {lab=row_n[8]}
N 1580 -3530 1710 -3530 {lab=row_n[8]}
N 1360 -3510 1370 -3520 {lab=rowon_n[8]}
N 1370 -3520 1570 -3520 {lab=rowon_n[8]}
N 1570 -3520 1580 -3510 {lab=rowon_n[8]}
N 1580 -3510 1710 -3510 {lab=rowon_n[8]}
N 1360 -3490 1370 -3500 {lab=#net15}
N 1370 -3500 1570 -3500 {lab=#net15}
N 1570 -3500 1580 -3490 {lab=#net15}
N 1580 -3490 1710 -3490 {lab=#net15}
N 1360 -3470 1380 -3480 {lab=#net16}
N 1380 -3480 1570 -3480 {lab=#net16}
N 1570 -3480 1580 -3470 {lab=#net16}
N 1580 -3470 1710 -3470 {lab=#net16}
N 1360 -3550 1370 -3560 {lab=rowoff_n[8]}
N 1370 -3560 1570 -3560 {lab=rowoff_n[8]}
N 1570 -3560 1580 -3550 {lab=rowoff_n[8]}
N 1580 -3550 1710 -3550 {lab=rowoff_n[8]}
N 1710 -3550 1720 -3560 {lab=rowoff_n[8]}
N 1720 -3560 1920 -3560 {lab=rowoff_n[8]}
N 1920 -3560 1930 -3550 {lab=rowoff_n[8]}
N 1930 -3550 2060 -3550 {lab=rowoff_n[8]}
N 1710 -3530 1720 -3540 {lab=row_n[8]}
N 1720 -3540 1920 -3540 {lab=row_n[8]}
N 1920 -3540 1930 -3530 {lab=row_n[8]}
N 1930 -3530 2060 -3530 {lab=row_n[8]}
N 1710 -3510 1720 -3520 {lab=rowon_n[8]}
N 1720 -3520 1920 -3520 {lab=rowon_n[8]}
N 1920 -3520 1930 -3510 {lab=rowon_n[8]}
N 1930 -3510 2060 -3510 {lab=rowon_n[8]}
N 1710 -3490 1720 -3500 {lab=#net15}
N 1720 -3500 1920 -3500 {lab=#net15}
N 1920 -3500 1930 -3490 {lab=#net15}
N 1930 -3490 2060 -3490 {lab=#net15}
N 1710 -3470 1720 -3480 {lab=#net16}
N 1720 -3480 1920 -3480 {lab=#net16}
N 1920 -3480 1930 -3470 {lab=#net16}
N 1930 -3470 2060 -3470 {lab=#net16}
N 2060 -3550 2070 -3560 {lab=rowoff_n[8]}
N 2070 -3560 2270 -3560 {lab=rowoff_n[8]}
N 2270 -3560 2280 -3550 {lab=rowoff_n[8]}
N 2280 -3550 2410 -3550 {lab=rowoff_n[8]}
N 2060 -3530 2070 -3540 {lab=row_n[8]}
N 2070 -3540 2270 -3540 {lab=row_n[8]}
N 2270 -3540 2280 -3530 {lab=row_n[8]}
N 2280 -3530 2410 -3530 {lab=row_n[8]}
N 2060 -3510 2070 -3520 {lab=rowon_n[8]}
N 2070 -3520 2270 -3520 {lab=rowon_n[8]}
N 2270 -3520 2280 -3510 {lab=rowon_n[8]}
N 2280 -3510 2410 -3510 {lab=rowon_n[8]}
N 2270 -3500 2280 -3490 {lab=#net15}
N 2280 -3490 2410 -3490 {lab=#net15}
N 2060 -3470 2070 -3480 {lab=#net16}
N 2070 -3480 2270 -3480 {lab=#net16}
N 2270 -3480 2280 -3470 {lab=#net16}
N 2280 -3470 2410 -3470 {lab=#net16}
N 2060 -3490 2070 -3500 {lab=#net15}
N 2070 -3500 2270 -3500 {lab=#net15}
N 2410 -3550 2420 -3560 {lab=rowoff_n[8]}
N 2420 -3560 2620 -3560 {lab=rowoff_n[8]}
N 2620 -3560 2630 -3550 {lab=rowoff_n[8]}
N 2630 -3550 2750 -3550 {lab=rowoff_n[8]}
N 2410 -3530 2420 -3540 {lab=row_n[8]}
N 2420 -3540 2620 -3540 {lab=row_n[8]}
N 2620 -3540 2630 -3530 {lab=row_n[8]}
N 2630 -3530 2750 -3530 {lab=row_n[8]}
N 2410 -3510 2420 -3520 {lab=rowon_n[8]}
N 2420 -3520 2620 -3520 {lab=rowon_n[8]}
N 2620 -3520 2630 -3510 {lab=rowon_n[8]}
N 2630 -3510 2750 -3510 {lab=rowon_n[8]}
N 2410 -3490 2420 -3500 {lab=#net15}
N 2420 -3500 2620 -3500 {lab=#net15}
N 2620 -3500 2630 -3490 {lab=#net15}
N 2630 -3490 2750 -3490 {lab=#net15}
N 2410 -3470 2420 -3480 {lab=#net16}
N 2420 -3480 2620 -3480 {lab=#net16}
N 2620 -3480 2630 -3470 {lab=#net16}
N 2630 -3470 2750 -3470 {lab=#net16}
N 2750 -3550 2760 -3560 {lab=rowoff_n[8]}
N 2760 -3560 2960 -3560 {lab=rowoff_n[8]}
N 2960 -3560 2970 -3550 {lab=rowoff_n[8]}
N 2970 -3550 3100 -3550 {lab=rowoff_n[8]}
N 2750 -3530 2760 -3540 {lab=row_n[8]}
N 2760 -3540 2960 -3540 {lab=row_n[8]}
N 2960 -3540 2970 -3530 {lab=row_n[8]}
N 2970 -3530 3100 -3530 {lab=row_n[8]}
N 2750 -3510 2760 -3520 {lab=rowon_n[8]}
N 2760 -3520 2960 -3520 {lab=rowon_n[8]}
N 2960 -3520 2970 -3510 {lab=rowon_n[8]}
N 2970 -3510 3100 -3510 {lab=rowon_n[8]}
N 2750 -3490 2760 -3500 {lab=#net15}
N 2760 -3500 2960 -3500 {lab=#net15}
N 2750 -3470 2760 -3480 {lab=#net16}
N 2760 -3480 2960 -3480 {lab=#net16}
N 2960 -3480 2970 -3470 {lab=#net16}
N 2970 -3470 3100 -3470 {lab=#net16}
N 2960 -3500 2970 -3490 {lab=#net15}
N 2970 -3490 3100 -3490 {lab=#net15}
N 3100 -3550 3110 -3560 {lab=rowoff_n[8]}
N 3110 -3560 3310 -3560 {lab=rowoff_n[8]}
N 3310 -3560 3320 -3550 {lab=rowoff_n[8]}
N 3320 -3550 3460 -3550 {lab=rowoff_n[8]}
N 3100 -3530 3110 -3540 {lab=row_n[8]}
N 3110 -3540 3310 -3540 {lab=row_n[8]}
N 3310 -3540 3320 -3530 {lab=row_n[8]}
N 3320 -3530 3460 -3530 {lab=row_n[8]}
N 3100 -3510 3110 -3520 {lab=rowon_n[8]}
N 3110 -3520 3310 -3520 {lab=rowon_n[8]}
N 3310 -3520 3320 -3510 {lab=rowon_n[8]}
N 3320 -3510 3460 -3510 {lab=rowon_n[8]}
N 3100 -3490 3110 -3500 {lab=#net15}
N 3110 -3500 3310 -3500 {lab=#net15}
N 3310 -3500 3320 -3490 {lab=#net15}
N 3320 -3490 3460 -3490 {lab=#net15}
N 3100 -3470 3110 -3480 {lab=#net16}
N 3110 -3480 3310 -3480 {lab=#net16}
N 3310 -3480 3320 -3470 {lab=#net16}
N 3320 -3470 3460 -3470 {lab=#net16}
N 3460 -3550 3470 -3560 {lab=rowoff_n[8]}
N 3470 -3560 3670 -3560 {lab=rowoff_n[8]}
N 3670 -3560 3680 -3550 {lab=rowoff_n[8]}
N 3680 -3550 3790 -3550 {lab=rowoff_n[8]}
N 3460 -3530 3470 -3540 {lab=row_n[8]}
N 3470 -3540 3670 -3540 {lab=row_n[8]}
N 3670 -3540 3680 -3530 {lab=row_n[8]}
N 3680 -3530 3790 -3530 {lab=row_n[8]}
N 3460 -3510 3470 -3520 {lab=rowon_n[8]}
N 3470 -3520 3670 -3520 {lab=rowon_n[8]}
N 3670 -3520 3680 -3510 {lab=rowon_n[8]}
N 3680 -3510 3790 -3510 {lab=rowon_n[8]}
N 3460 -3490 3470 -3500 {lab=#net15}
N 3470 -3500 3670 -3500 {lab=#net15}
N 3670 -3500 3680 -3490 {lab=#net15}
N 3680 -3490 3790 -3490 {lab=#net15}
N 3460 -3470 3470 -3480 {lab=#net16}
N 3470 -3480 3670 -3480 {lab=#net16}
N 3670 -3480 3680 -3470 {lab=#net16}
N 3680 -3470 3790 -3470 {lab=#net16}
N 3790 -3550 3800 -3560 {lab=rowoff_n[8]}
N 3800 -3560 4000 -3560 {lab=rowoff_n[8]}
N 4000 -3560 4010 -3550 {lab=rowoff_n[8]}
N 4010 -3550 4120 -3550 {lab=rowoff_n[8]}
N 3790 -3530 3800 -3540 {lab=row_n[8]}
N 3800 -3540 4000 -3540 {lab=row_n[8]}
N 4000 -3540 4010 -3530 {lab=row_n[8]}
N 4010 -3530 4120 -3530 {lab=row_n[8]}
N 3790 -3510 3800 -3520 {lab=rowon_n[8]}
N 3800 -3520 4000 -3520 {lab=rowon_n[8]}
N 4000 -3520 4010 -3510 {lab=rowon_n[8]}
N 4010 -3510 4120 -3510 {lab=rowon_n[8]}
N 3790 -3490 3800 -3500 {lab=#net15}
N 3800 -3500 4000 -3500 {lab=#net15}
N 4000 -3500 4010 -3490 {lab=#net15}
N 4010 -3490 4120 -3490 {lab=#net15}
N 3790 -3470 3800 -3480 {lab=#net16}
N 3800 -3480 4000 -3480 {lab=#net16}
N 4000 -3480 4020 -3470 {lab=#net16}
N 4020 -3470 4120 -3470 {lab=#net16}
N 4120 -3550 4130 -3560 {lab=rowoff_n[8]}
N 4130 -3560 4330 -3560 {lab=rowoff_n[8]}
N 4330 -3560 4340 -3550 {lab=rowoff_n[8]}
N 4340 -3550 4470 -3550 {lab=rowoff_n[8]}
N 4120 -3530 4130 -3540 {lab=row_n[8]}
N 4130 -3540 4330 -3540 {lab=row_n[8]}
N 4330 -3540 4340 -3530 {lab=row_n[8]}
N 4340 -3530 4470 -3530 {lab=row_n[8]}
N 4120 -3510 4130 -3520 {lab=rowon_n[8]}
N 4130 -3520 4330 -3520 {lab=rowon_n[8]}
N 4330 -3520 4340 -3510 {lab=rowon_n[8]}
N 4340 -3510 4470 -3510 {lab=rowon_n[8]}
N 4120 -3490 4130 -3500 {lab=#net15}
N 4130 -3500 4330 -3500 {lab=#net15}
N 4330 -3500 4340 -3490 {lab=#net15}
N 4340 -3490 4470 -3490 {lab=#net15}
N 4120 -3470 4130 -3480 {lab=#net16}
N 4130 -3480 4330 -3480 {lab=#net16}
N 4330 -3480 4340 -3470 {lab=#net16}
N 4340 -3470 4470 -3470 {lab=#net16}
N 4470 -3550 4480 -3560 {lab=rowoff_n[8]}
N 4480 -3560 4680 -3560 {lab=rowoff_n[8]}
N 4680 -3560 4690 -3550 {lab=rowoff_n[8]}
N 4690 -3550 4820 -3550 {lab=rowoff_n[8]}
N 4470 -3530 4480 -3540 {lab=row_n[8]}
N 4480 -3540 4680 -3540 {lab=row_n[8]}
N 4470 -3510 4480 -3520 {lab=rowon_n[8]}
N 4480 -3520 4680 -3520 {lab=rowon_n[8]}
N 4680 -3520 4690 -3510 {lab=rowon_n[8]}
N 4690 -3510 4820 -3510 {lab=rowon_n[8]}
N 4680 -3540 4690 -3530 {lab=row_n[8]}
N 4690 -3530 4820 -3530 {lab=row_n[8]}
N 4470 -3490 4480 -3500 {lab=#net15}
N 4480 -3500 4680 -3500 {lab=#net15}
N 4680 -3500 4690 -3490 {lab=#net15}
N 4690 -3490 4820 -3490 {lab=#net15}
N 4470 -3470 4480 -3480 {lab=#net16}
N 4480 -3480 4680 -3480 {lab=#net16}
N 4680 -3480 4690 -3470 {lab=#net16}
N 4690 -3470 4820 -3470 {lab=#net16}
N 4820 -3550 4830 -3560 {lab=rowoff_n[8]}
N 4830 -3560 5030 -3560 {lab=rowoff_n[8]}
N 5030 -3560 5040 -3550 {lab=rowoff_n[8]}
N 5040 -3550 5160 -3550 {lab=rowoff_n[8]}
N 4820 -3530 4830 -3540 {lab=row_n[8]}
N 4830 -3540 5030 -3540 {lab=row_n[8]}
N 5030 -3540 5040 -3530 {lab=row_n[8]}
N 5040 -3530 5160 -3530 {lab=row_n[8]}
N 4820 -3510 4830 -3520 {lab=rowon_n[8]}
N 4830 -3520 5030 -3520 {lab=rowon_n[8]}
N 5030 -3520 5040 -3510 {lab=rowon_n[8]}
N 5040 -3510 5160 -3510 {lab=rowon_n[8]}
N 4820 -3490 4830 -3500 {lab=#net15}
N 4830 -3500 5030 -3500 {lab=#net15}
N 5030 -3500 5040 -3490 {lab=#net15}
N 5040 -3490 5160 -3490 {lab=#net15}
N 4820 -3470 4830 -3480 {lab=#net16}
N 4830 -3480 5030 -3480 {lab=#net16}
N 5030 -3480 5040 -3470 {lab=#net16}
N 5040 -3470 5160 -3470 {lab=#net16}
N 5160 -3550 5170 -3560 {lab=rowoff_n[8]}
N 5170 -3560 5370 -3560 {lab=rowoff_n[8]}
N 5370 -3560 5380 -3550 {lab=rowoff_n[8]}
N 5380 -3550 5500 -3550 {lab=rowoff_n[8]}
N 5160 -3530 5170 -3540 {lab=row_n[8]}
N 5170 -3540 5370 -3540 {lab=row_n[8]}
N 5370 -3540 5380 -3530 {lab=row_n[8]}
N 5380 -3530 5500 -3530 {lab=row_n[8]}
N 5160 -3510 5170 -3520 {lab=rowon_n[8]}
N 5170 -3520 5370 -3520 {lab=rowon_n[8]}
N 5370 -3520 5380 -3510 {lab=rowon_n[8]}
N 5380 -3510 5500 -3510 {lab=rowon_n[8]}
N 5160 -3490 5170 -3500 {lab=#net15}
N 5170 -3500 5370 -3500 {lab=#net15}
N 5370 -3500 5380 -3490 {lab=#net15}
N 5380 -3490 5500 -3490 {lab=#net15}
N 5160 -3470 5170 -3480 {lab=#net16}
N 5170 -3480 5370 -3480 {lab=#net16}
N 5370 -3480 5390 -3470 {lab=#net16}
N 5390 -3470 5500 -3470 {lab=#net16}
N 5500 -3550 5510 -3560 {lab=rowoff_n[8]}
N 5510 -3560 5710 -3560 {lab=rowoff_n[8]}
N 5500 -3530 5510 -3540 {lab=row_n[8]}
N 5510 -3540 5710 -3540 {lab=row_n[8]}
N 5710 -3540 5720 -3530 {lab=row_n[8]}
N 5710 -3560 5720 -3550 {lab=rowoff_n[8]}
N 5500 -3510 5510 -3520 {lab=rowon_n[8]}
N 5510 -3520 5710 -3520 {lab=rowon_n[8]}
N 5500 -3490 5510 -3500 {lab=#net15}
N 5510 -3500 5710 -3500 {lab=#net15}
N 5710 -3500 5720 -3490 {lab=#net15}
N 5500 -3470 5510 -3480 {lab=#net16}
N 5510 -3480 5710 -3480 {lab=#net16}
N 5710 -3480 5720 -3470 {lab=#net16}
N 5710 -3520 5720 -3510 {lab=rowon_n[8]}
N 830 -3060 840 -3070 {lab=VDD}
N 840 -3320 840 -3070 {lab=VDD}
N 830 -3330 840 -3320 {lab=VDD}
N 830 -3390 830 -3330 {lab=VDD}
N 850 -3390 850 -3330 {lab=VSS}
N 850 -3330 860 -3320 {lab=VSS}
N 860 -3320 860 -3070 {lab=VSS}
N 850 -3060 860 -3070 {lab=VSS}
N 1160 -3320 1160 -3070 {lab=col_n[0]}
N 1150 -3330 1160 -3320 {lab=col_n[0]}
N 1150 -3390 1150 -3330 {lab=col_n[0]}
N 1170 -3390 1170 -3330 {lab=col[0]}
N 1170 -3330 1180 -3320 {lab=col[0]}
N 1180 -3320 1180 -3070 {lab=col[0]}
N 1490 -3320 1490 -3070 {lab=col_n[1]}
N 1480 -3330 1490 -3320 {lab=col_n[1]}
N 1480 -3390 1480 -3330 {lab=col_n[1]}
N 1500 -3390 1500 -3330 {lab=col[1]}
N 1500 -3330 1510 -3320 {lab=col[1]}
N 1510 -3320 1510 -3070 {lab=col[1]}
N 1840 -3320 1840 -3070 {lab=col_n[2]}
N 1830 -3330 1840 -3320 {lab=col_n[2]}
N 1830 -3390 1830 -3330 {lab=col_n[2]}
N 1850 -3390 1850 -3330 {lab=col[2]}
N 1850 -3330 1860 -3320 {lab=col[2]}
N 1860 -3320 1860 -3070 {lab=col[2]}
N 2190 -3320 2190 -3070 {lab=col_n[3]}
N 2180 -3330 2190 -3320 {lab=col_n[3]}
N 2180 -3390 2180 -3330 {lab=col_n[3]}
N 2200 -3390 2200 -3330 {lab=col[3]}
N 2200 -3330 2210 -3320 {lab=col[3]}
N 2210 -3320 2210 -3070 {lab=col[3]}
N 2540 -3320 2540 -3070 {lab=col_n[4]}
N 2530 -3330 2540 -3320 {lab=col_n[4]}
N 2530 -3390 2530 -3330 {lab=col_n[4]}
N 2550 -3390 2550 -3330 {lab=col[4]}
N 2550 -3330 2560 -3320 {lab=col[4]}
N 2560 -3320 2560 -3070 {lab=col[4]}
N 2880 -3320 2880 -3070 {lab=col_n[5]}
N 2870 -3330 2880 -3320 {lab=col_n[5]}
N 2870 -3390 2870 -3330 {lab=col_n[5]}
N 2890 -3390 2890 -3330 {lab=col[5]}
N 2890 -3330 2900 -3320 {lab=col[5]}
N 2900 -3320 2900 -3070 {lab=col[5]}
N 3230 -3320 3230 -3070 {lab=col_n[6]}
N 3220 -3330 3230 -3320 {lab=col_n[6]}
N 3220 -3390 3220 -3330 {lab=col_n[6]}
N 3240 -3390 3240 -3330 {lab=col[6]}
N 3240 -3330 3250 -3320 {lab=col[6]}
N 3250 -3320 3250 -3070 {lab=col[6]}
N 3590 -3320 3590 -3070 {lab=col_n[7]}
N 3580 -3330 3590 -3320 {lab=col_n[7]}
N 3580 -3390 3580 -3330 {lab=col_n[7]}
N 3600 -3390 3600 -3330 {lab=col[7]}
N 3600 -3330 3610 -3320 {lab=col[7]}
N 3610 -3320 3610 -3070 {lab=col[7]}
N 3920 -3320 3920 -3070 {lab=col_n[8]}
N 3910 -3330 3920 -3320 {lab=col_n[8]}
N 3910 -3390 3910 -3330 {lab=col_n[8]}
N 3930 -3390 3930 -3330 {lab=col[8]}
N 3930 -3330 3940 -3320 {lab=col[8]}
N 3940 -3320 3940 -3070 {lab=col[8]}
N 4250 -3320 4250 -3070 {lab=col_n[9]}
N 4240 -3330 4250 -3320 {lab=col_n[9]}
N 4240 -3390 4240 -3330 {lab=col_n[9]}
N 4260 -3390 4260 -3330 {lab=col[9]}
N 4260 -3330 4270 -3320 {lab=col[9]}
N 4270 -3320 4270 -3070 {lab=col[9]}
N 4600 -3320 4600 -3070 {lab=col_n[10]}
N 4590 -3330 4600 -3320 {lab=col_n[10]}
N 4590 -3390 4590 -3330 {lab=col_n[10]}
N 4610 -3390 4610 -3330 {lab=col[10]}
N 4610 -3330 4620 -3320 {lab=col[10]}
N 4620 -3320 4620 -3070 {lab=col[10]}
N 4950 -3320 4950 -3070 {lab=col_n[11]}
N 4940 -3330 4950 -3320 {lab=col_n[11]}
N 4940 -3390 4940 -3330 {lab=col_n[11]}
N 4960 -3390 4960 -3330 {lab=col[11]}
N 4960 -3330 4970 -3320 {lab=col[11]}
N 4970 -3320 4970 -3070 {lab=col[11]}
N 5290 -3320 5290 -3070 {lab=col_n[12]}
N 5280 -3330 5290 -3320 {lab=col_n[12]}
N 5280 -3390 5280 -3330 {lab=col_n[12]}
N 5300 -3390 5300 -3330 {lab=col[12]}
N 5300 -3330 5310 -3320 {lab=col[12]}
N 5310 -3320 5310 -3070 {lab=col[12]}
N 5630 -3320 5630 -3070 {lab=VDD}
N 5620 -3330 5630 -3320 {lab=VDD}
N 5620 -3390 5620 -3330 {lab=VDD}
N 5640 -3390 5640 -3330 {lab=VSS}
N 5640 -3330 5650 -3320 {lab=VSS}
N 5650 -3320 5650 -3070 {lab=VSS}
N 5640 -3060 5650 -3070 {lab=VSS}
N 5620 -3060 5630 -3070 {lab=VDD}
N 5280 -3060 5290 -3070 {lab=col_n[12]}
N 5300 -3060 5310 -3070 {lab=col[12]}
N 4940 -3060 4950 -3070 {lab=col_n[11]}
N 4960 -3060 4970 -3070 {lab=col[11]}
N 4590 -3060 4600 -3070 {lab=col_n[10]}
N 4610 -3060 4620 -3070 {lab=col[10]}
N 4260 -3060 4270 -3070 {lab=col[9]}
N 4240 -3060 4250 -3070 {lab=col_n[9]}
N 3930 -3060 3940 -3070 {lab=col[8]}
N 3910 -3060 3920 -3070 {lab=col_n[8]}
N 3580 -3060 3590 -3070 {lab=col_n[7]}
N 3600 -3060 3610 -3070 {lab=col[7]}
N 3220 -3060 3230 -3070 {lab=col_n[6]}
N 3240 -3060 3250 -3070 {lab=col[6]}
N 2890 -3060 2900 -3070 {lab=col[5]}
N 2870 -3060 2880 -3070 {lab=col_n[5]}
N 2550 -3060 2560 -3070 {lab=col[4]}
N 2530 -3060 2540 -3070 {lab=col_n[4]}
N 2200 -3060 2210 -3070 {lab=col[3]}
N 2180 -3060 2190 -3070 {lab=col_n[3]}
N 1850 -3060 1860 -3070 {lab=col[2]}
N 1830 -3060 1840 -3070 {lab=col_n[2]}
N 1500 -3060 1510 -3070 {lab=col[1]}
N 1480 -3060 1490 -3070 {lab=col_n[1]}
N 1150 -3060 1160 -3070 {lab=col_n[0]}
N 1170 -3060 1180 -3070 {lab=col[0]}
N 830 -3060 830 -3020 {lab=VDD}
N 850 -3060 850 -3020 {lab=VSS}
N 830 -2740 840 -2750 {lab=VDD}
N 840 -3010 840 -2750 {lab=VDD}
N 830 -3020 840 -3010 {lab=VDD}
N 850 -3020 860 -3010 {lab=VSS}
N 860 -3010 860 -2750 {lab=VSS}
N 850 -2740 860 -2750 {lab=VSS}
N 1150 -3060 1150 -3020 {lab=col_n[0]}
N 1170 -3060 1170 -3020 {lab=col[0]}
N 1160 -3010 1160 -2750 {lab=col_n[0]}
N 1150 -3020 1160 -3010 {lab=col_n[0]}
N 1170 -3020 1180 -3010 {lab=col[0]}
N 1180 -3010 1180 -2750 {lab=col[0]}
N 1480 -3060 1480 -3020 {lab=col_n[1]}
N 1500 -3060 1500 -3020 {lab=col[1]}
N 1490 -3010 1490 -2750 {lab=col_n[1]}
N 1480 -3020 1490 -3010 {lab=col_n[1]}
N 1500 -3020 1510 -3010 {lab=col[1]}
N 1510 -3010 1510 -2750 {lab=col[1]}
N 1830 -3060 1830 -3020 {lab=col_n[2]}
N 1850 -3060 1850 -3020 {lab=col[2]}
N 1840 -3010 1840 -2750 {lab=col_n[2]}
N 1830 -3020 1840 -3010 {lab=col_n[2]}
N 1850 -3020 1860 -3010 {lab=col[2]}
N 1860 -3010 1860 -2750 {lab=col[2]}
N 2180 -3060 2180 -3020 {lab=col_n[3]}
N 2200 -3060 2200 -3020 {lab=col[3]}
N 2190 -3010 2190 -2750 {lab=col_n[3]}
N 2180 -3020 2190 -3010 {lab=col_n[3]}
N 2200 -3020 2210 -3010 {lab=col[3]}
N 2210 -3010 2210 -2750 {lab=col[3]}
N 2530 -3060 2530 -3020 {lab=col_n[4]}
N 2550 -3060 2550 -3020 {lab=col[4]}
N 2540 -3010 2540 -2750 {lab=col_n[4]}
N 2530 -3020 2540 -3010 {lab=col_n[4]}
N 2550 -3020 2560 -3010 {lab=col[4]}
N 2560 -3010 2560 -2750 {lab=col[4]}
N 2870 -3060 2870 -3020 {lab=col_n[5]}
N 2890 -3060 2890 -3020 {lab=col[5]}
N 2880 -3010 2880 -2750 {lab=col_n[5]}
N 2870 -3020 2880 -3010 {lab=col_n[5]}
N 2890 -3020 2900 -3010 {lab=col[5]}
N 2900 -3010 2900 -2750 {lab=col[5]}
N 3220 -3060 3220 -3020 {lab=col_n[6]}
N 3240 -3060 3240 -3020 {lab=col[6]}
N 3230 -3010 3230 -2750 {lab=col_n[6]}
N 3220 -3020 3230 -3010 {lab=col_n[6]}
N 3240 -3020 3250 -3010 {lab=col[6]}
N 3250 -3010 3250 -2750 {lab=col[6]}
N 3580 -3060 3580 -3020 {lab=col_n[7]}
N 3600 -3060 3600 -3020 {lab=col[7]}
N 3590 -3010 3590 -2750 {lab=col_n[7]}
N 3580 -3020 3590 -3010 {lab=col_n[7]}
N 3600 -3020 3610 -3010 {lab=col[7]}
N 3610 -3010 3610 -2750 {lab=col[7]}
N 3910 -3060 3910 -3020 {lab=col_n[8]}
N 3930 -3060 3930 -3020 {lab=col[8]}
N 3920 -3010 3920 -2750 {lab=col_n[8]}
N 3910 -3020 3920 -3010 {lab=col_n[8]}
N 3930 -3020 3940 -3010 {lab=col[8]}
N 3940 -3010 3940 -2750 {lab=col[8]}
N 4590 -3060 4590 -3020 {lab=col_n[10]}
N 4610 -3060 4610 -3020 {lab=col[10]}
N 4600 -3010 4600 -2750 {lab=col_n[10]}
N 4590 -3020 4600 -3010 {lab=col_n[10]}
N 4610 -3020 4620 -3010 {lab=col[10]}
N 4620 -3010 4620 -2750 {lab=col[10]}
N 4940 -3060 4940 -3020 {lab=col_n[11]}
N 4960 -3060 4960 -3020 {lab=col[11]}
N 4950 -3010 4950 -2750 {lab=col_n[11]}
N 4940 -3020 4950 -3010 {lab=col_n[11]}
N 4960 -3020 4970 -3010 {lab=col[11]}
N 4970 -3010 4970 -2750 {lab=col[11]}
N 5280 -3060 5280 -3020 {lab=col_n[12]}
N 5300 -3060 5300 -3020 {lab=col[12]}
N 5290 -3010 5290 -2750 {lab=col_n[12]}
N 5280 -3020 5290 -3010 {lab=col_n[12]}
N 5300 -3020 5310 -3010 {lab=col[12]}
N 5310 -3010 5310 -2750 {lab=col[12]}
N 5620 -3060 5620 -3020 {lab=VDD}
N 5640 -3060 5640 -3020 {lab=VSS}
N 5630 -3010 5630 -2750 {lab=VDD}
N 5620 -3020 5630 -3010 {lab=VDD}
N 5640 -3020 5650 -3010 {lab=VSS}
N 5650 -3010 5650 -2750 {lab=VSS}
N 5640 -2740 5650 -2750 {lab=VSS}
N 5620 -2740 5630 -2750 {lab=VDD}
N 5300 -2740 5310 -2750 {lab=col[12]}
N 5280 -2740 5290 -2750 {lab=col_n[12]}
N 4960 -2740 4970 -2750 {lab=col[11]}
N 4940 -2740 4950 -2750 {lab=col_n[11]}
N 4610 -2740 4620 -2750 {lab=col[10]}
N 4590 -2740 4600 -2750 {lab=col_n[10]}
N 4240 -3060 4240 -3020 {lab=col_n[9]}
N 4260 -3060 4260 -3020 {lab=col[9]}
N 4250 -3010 4250 -2750 {lab=col_n[9]}
N 4240 -3020 4250 -3010 {lab=col_n[9]}
N 4260 -3020 4270 -3010 {lab=col[9]}
N 4270 -3010 4270 -2750 {lab=col[9]}
N 4260 -2740 4270 -2750 {lab=col[9]}
N 4240 -2740 4250 -2750 {lab=col_n[9]}
N 3930 -2740 3940 -2750 {lab=col[8]}
N 3910 -2740 3920 -2750 {lab=col_n[8]}
N 3600 -2740 3610 -2750 {lab=col[7]}
N 3580 -2740 3590 -2750 {lab=col_n[7]}
N 3240 -2740 3250 -2750 {lab=col[6]}
N 3220 -2740 3230 -2750 {lab=col_n[6]}
N 2890 -2740 2900 -2750 {lab=col[5]}
N 2870 -2740 2880 -2750 {lab=col_n[5]}
N 2550 -2740 2560 -2750 {lab=col[4]}
N 2530 -2740 2540 -2750 {lab=col_n[4]}
N 1150 -2740 1160 -2750 {lab=col_n[0]}
N 1170 -2740 1180 -2750 {lab=col[0]}
N 1480 -2740 1490 -2750 {lab=col_n[1]}
N 1500 -2740 1510 -2750 {lab=col[1]}
N 1830 -2740 1840 -2750 {lab=col_n[2]}
N 1850 -2740 1860 -2750 {lab=col[2]}
N 2180 -2740 2190 -2750 {lab=col_n[3]}
N 2200 -2740 2210 -2750 {lab=col[3]}
N 830 -2060 840 -2070 {lab=VDD}
N 840 -2360 840 -2070 {lab=VDD}
N 830 -2370 840 -2360 {lab=VDD}
N 850 -2060 860 -2070 {lab=VSS}
N 860 -2360 860 -2070 {lab=VSS}
N 850 -2370 860 -2360 {lab=VSS}
N 1150 -2410 1150 -2370 {lab=col_n[0]}
N 1170 -2410 1170 -2370 {lab=col[0]}
N 1160 -2360 1160 -2070 {lab=col_n[0]}
N 1150 -2370 1160 -2360 {lab=col_n[0]}
N 1180 -2360 1180 -2070 {lab=col[0]}
N 1170 -2370 1180 -2360 {lab=col[0]}
N 1480 -2410 1480 -2370 {lab=col_n[1]}
N 1500 -2410 1500 -2370 {lab=col[1]}
N 1490 -2360 1490 -2070 {lab=col_n[1]}
N 1480 -2370 1490 -2360 {lab=col_n[1]}
N 1510 -2360 1510 -2070 {lab=col[1]}
N 1500 -2370 1510 -2360 {lab=col[1]}
N 1830 -2410 1830 -2370 {lab=col_n[2]}
N 1850 -2410 1850 -2370 {lab=col[2]}
N 1840 -2360 1840 -2070 {lab=col_n[2]}
N 1830 -2370 1840 -2360 {lab=col_n[2]}
N 1860 -2360 1860 -2070 {lab=col[2]}
N 1850 -2370 1860 -2360 {lab=col[2]}
N 2180 -2410 2180 -2370 {lab=col_n[3]}
N 2200 -2410 2200 -2370 {lab=col[3]}
N 2190 -2360 2190 -2070 {lab=col_n[3]}
N 2180 -2370 2190 -2360 {lab=col_n[3]}
N 2210 -2360 2210 -2070 {lab=col[3]}
N 2200 -2370 2210 -2360 {lab=col[3]}
N 2530 -2410 2530 -2370 {lab=col_n[4]}
N 2550 -2410 2550 -2370 {lab=col[4]}
N 2540 -2360 2540 -2070 {lab=col_n[4]}
N 2530 -2370 2540 -2360 {lab=col_n[4]}
N 2560 -2360 2560 -2070 {lab=col[4]}
N 2550 -2370 2560 -2360 {lab=col[4]}
N 2870 -2410 2870 -2370 {lab=col_n[5]}
N 2890 -2410 2890 -2370 {lab=col[5]}
N 2880 -2360 2880 -2070 {lab=col_n[5]}
N 2870 -2370 2880 -2360 {lab=col_n[5]}
N 2900 -2360 2900 -2070 {lab=col[5]}
N 2890 -2370 2900 -2360 {lab=col[5]}
N 3220 -2410 3220 -2370 {lab=col_n[6]}
N 3240 -2410 3240 -2370 {lab=col[6]}
N 3230 -2360 3230 -2070 {lab=col_n[6]}
N 3220 -2370 3230 -2360 {lab=col_n[6]}
N 3250 -2360 3250 -2070 {lab=col[6]}
N 3240 -2370 3250 -2360 {lab=col[6]}
N 3580 -2410 3580 -2370 {lab=col_n[7]}
N 3600 -2410 3600 -2370 {lab=col[7]}
N 3590 -2360 3590 -2070 {lab=col_n[7]}
N 3580 -2370 3590 -2360 {lab=col_n[7]}
N 3610 -2360 3610 -2070 {lab=col[7]}
N 3600 -2370 3610 -2360 {lab=col[7]}
N 3910 -2410 3910 -2370 {lab=col_n[8]}
N 3930 -2410 3930 -2370 {lab=col[8]}
N 3920 -2360 3920 -2070 {lab=col_n[8]}
N 3910 -2370 3920 -2360 {lab=col_n[8]}
N 3940 -2360 3940 -2070 {lab=col[8]}
N 3930 -2370 3940 -2360 {lab=col[8]}
N 4240 -2410 4240 -2370 {lab=col_n[9]}
N 4260 -2410 4260 -2370 {lab=col[9]}
N 4250 -2360 4250 -2070 {lab=col_n[9]}
N 4240 -2370 4250 -2360 {lab=col_n[9]}
N 4270 -2360 4270 -2070 {lab=col[9]}
N 4260 -2370 4270 -2360 {lab=col[9]}
N 4590 -2410 4590 -2370 {lab=col_n[10]}
N 4610 -2410 4610 -2370 {lab=col[10]}
N 4600 -2360 4600 -2070 {lab=col_n[10]}
N 4590 -2370 4600 -2360 {lab=col_n[10]}
N 4620 -2360 4620 -2070 {lab=col[10]}
N 4610 -2370 4620 -2360 {lab=col[10]}
N 4940 -2410 4940 -2370 {lab=col_n[11]}
N 4960 -2410 4960 -2370 {lab=col[11]}
N 4950 -2360 4950 -2070 {lab=col_n[11]}
N 4940 -2370 4950 -2360 {lab=col_n[11]}
N 4970 -2360 4970 -2070 {lab=col[11]}
N 4960 -2370 4970 -2360 {lab=col[11]}
N 5280 -2410 5280 -2370 {lab=col_n[12]}
N 5300 -2410 5300 -2370 {lab=col[12]}
N 5290 -2360 5290 -2070 {lab=col_n[12]}
N 5280 -2370 5290 -2360 {lab=col_n[12]}
N 5310 -2360 5310 -2070 {lab=col[12]}
N 5300 -2370 5310 -2360 {lab=col[12]}
N 5620 -2410 5620 -2370 {lab=VDD}
N 5640 -2410 5640 -2370 {lab=VSS}
N 5630 -2360 5630 -2070 {lab=VDD}
N 5620 -2370 5630 -2360 {lab=VDD}
N 5650 -2360 5650 -2070 {lab=VSS}
N 5640 -2370 5650 -2360 {lab=VSS}
N 1150 -2060 1160 -2070 {lab=col_n[0]}
N 1170 -2060 1180 -2070 {lab=col[0]}
N 1480 -2060 1490 -2070 {lab=col_n[1]}
N 1500 -2060 1510 -2070 {lab=col[1]}
N 1830 -2060 1840 -2070 {lab=col_n[2]}
N 1850 -2060 1860 -2070 {lab=col[2]}
N 2180 -2060 2190 -2070 {lab=col_n[3]}
N 2200 -2060 2210 -2070 {lab=col[3]}
N 2530 -2060 2540 -2070 {lab=col_n[4]}
N 2550 -2060 2560 -2070 {lab=col[4]}
N 2870 -2060 2880 -2070 {lab=col_n[5]}
N 2890 -2060 2900 -2070 {lab=col[5]}
N 3580 -2060 3590 -2070 {lab=col_n[7]}
N 3600 -2060 3610 -2070 {lab=col[7]}
N 3220 -2060 3230 -2070 {lab=col_n[6]}
N 3240 -2060 3250 -2070 {lab=col[6]}
N 3910 -2060 3920 -2070 {lab=col_n[8]}
N 3930 -2060 3940 -2070 {lab=col[8]}
N 4260 -2060 4270 -2070 {lab=col[9]}
N 4240 -2060 4250 -2070 {lab=col_n[9]}
N 4590 -2060 4600 -2070 {lab=col_n[10]}
N 4610 -2060 4620 -2070 {lab=col[10]}
N 4940 -2060 4950 -2070 {lab=col_n[11]}
N 4960 -2060 4970 -2070 {lab=col[11]}
N 5280 -2060 5290 -2070 {lab=col_n[12]}
N 5300 -2060 5310 -2070 {lab=col[12]}
N 5620 -2060 5630 -2070 {lab=VDD}
N 5640 -2060 5650 -2070 {lab=VSS}
N 750 -3700 750 -3690 {
lab=VSS}
N 1070 -3700 1070 -3690 {
lab=VSS}
N 1400 -3700 1400 -3690 {
lab=VSS}
N 1750 -3700 1750 -3690 {
lab=VSS}
N 2100 -3700 2100 -3690 {
lab=VSS}
N 2450 -3700 2450 -3690 {
lab=VSS}
N 2790 -3700 2790 -3690 {
lab=VSS}
N 3140 -3700 3140 -3690 {
lab=VSS}
N 3500 -3700 3500 -3690 {
lab=VSS}
N 3830 -3700 3830 -3690 {
lab=VSS}
N 4160 -3700 4160 -3690 {
lab=VSS}
N 4510 -3700 4510 -3690 {
lab=VSS}
N 4860 -3700 4860 -3690 {
lab=VSS}
N 5200 -3700 5200 -3690 {
lab=VSS}
N 5540 -3700 5540 -3690 {
lab=VSS}
N 5560 -3940 5560 -3920 {
lab=vcm}
N 5540 -3930 5540 -3920 {
lab=VDD}
N 5600 -3940 5600 -3920 {
lab=ctop}
N 4880 -3940 4880 -3920 {
lab=vcm}
N 4860 -3930 4860 -3920 {
lab=VDD}
N 4920 -3940 4920 -3920 {
lab=ctop}
N 5220 -3940 5220 -3920 {
lab=vcm}
N 5200 -3930 5200 -3920 {
lab=VDD}
N 5260 -3940 5260 -3920 {
lab=ctop}
N 4530 -3940 4530 -3920 {
lab=vcm}
N 4510 -3930 4510 -3920 {
lab=VDD}
N 4570 -3940 4570 -3920 {
lab=ctop}
N 4180 -3940 4180 -3920 {
lab=vcm}
N 4160 -3930 4160 -3920 {
lab=VDD}
N 4220 -3940 4220 -3920 {
lab=ctop}
N 3850 -3940 3850 -3920 {
lab=vcm}
N 3830 -3930 3830 -3920 {
lab=VDD}
N 3890 -3940 3890 -3920 {
lab=ctop}
N 3520 -3940 3520 -3920 {
lab=vcm}
N 3500 -3930 3500 -3920 {
lab=VDD}
N 3560 -3940 3560 -3920 {
lab=ctop}
N 3160 -3940 3160 -3920 {
lab=vcm}
N 3140 -3930 3140 -3920 {
lab=VDD}
N 3200 -3940 3200 -3920 {
lab=ctop}
N 2810 -3940 2810 -3920 {
lab=vcm}
N 2790 -3930 2790 -3920 {
lab=VDD}
N 2850 -3940 2850 -3920 {
lab=ctop}
N 2470 -3940 2470 -3920 {
lab=vcm}
N 2450 -3930 2450 -3920 {
lab=VDD}
N 2510 -3940 2510 -3920 {
lab=ctop}
N 2120 -3940 2120 -3920 {
lab=vcm}
N 2100 -3930 2100 -3920 {
lab=VDD}
N 2160 -3940 2160 -3920 {
lab=ctop}
N 1770 -3940 1770 -3920 {
lab=vcm}
N 1750 -3930 1750 -3920 {
lab=VDD}
N 1810 -3940 1810 -3920 {
lab=ctop}
N 1420 -3940 1420 -3920 {
lab=vcm}
N 1400 -3930 1400 -3920 {
lab=VDD}
N 1460 -3940 1460 -3920 {
lab=ctop}
N 1090 -3940 1090 -3920 {
lab=vcm}
N 1070 -3930 1070 -3920 {
lab=VDD}
N 1130 -3940 1130 -3920 {
lab=ctop}
N 770 -3940 770 -3920 {
lab=vcm}
N 750 -3930 750 -3920 {
lab=VDD}
N 810 -3940 810 -3920 {
lab=ctop}
N 690 -3780 710 -3780 {
lab=sample_n}
N 690 -3800 710 -3800 {
lab=sample}
N 690 -3820 710 -3820 {
lab=rowon_n[9]}
N 690 -3840 710 -3840 {
lab=row_n[9]}
N 690 -3860 710 -3860 {
lab=rowoff_n[9]}
N 930 -3800 1030 -3800 {lab=#net17}
N 930 -3780 1030 -3780 {lab=#net18}
N 710 -3860 720 -3870 {lab=rowoff_n[9]}
N 720 -3870 940 -3870 {lab=rowoff_n[9]}
N 940 -3870 950 -3860 {lab=rowoff_n[9]}
N 950 -3860 1030 -3860 {lab=rowoff_n[9]}
N 710 -3840 720 -3850 {lab=row_n[9]}
N 720 -3850 940 -3850 {lab=row_n[9]}
N 940 -3850 950 -3840 {lab=row_n[9]}
N 950 -3840 1030 -3840 {lab=row_n[9]}
N 710 -3820 720 -3830 {lab=rowon_n[9]}
N 720 -3830 940 -3830 {lab=rowon_n[9]}
N 940 -3830 950 -3820 {lab=rowon_n[9]}
N 950 -3820 1030 -3820 {lab=rowon_n[9]}
N 1030 -3860 1040 -3870 {lab=rowoff_n[9]}
N 1030 -3840 1040 -3850 {lab=row_n[9]}
N 1040 -3850 1240 -3850 {lab=row_n[9]}
N 1240 -3850 1250 -3840 {lab=row_n[9]}
N 1250 -3840 1360 -3840 {lab=row_n[9]}
N 1040 -3870 1240 -3870 {lab=rowoff_n[9]}
N 1240 -3870 1250 -3860 {lab=rowoff_n[9]}
N 1250 -3860 1360 -3860 {lab=rowoff_n[9]}
N 1030 -3820 1040 -3830 {lab=rowon_n[9]}
N 1040 -3830 1240 -3830 {lab=rowon_n[9]}
N 1240 -3830 1250 -3820 {lab=rowon_n[9]}
N 1250 -3820 1360 -3820 {lab=rowon_n[9]}
N 1030 -3800 1040 -3810 {lab=#net17}
N 1040 -3810 1240 -3810 {lab=#net17}
N 1240 -3810 1250 -3800 {lab=#net17}
N 1250 -3800 1360 -3800 {lab=#net17}
N 1030 -3780 1040 -3790 {lab=#net18}
N 1040 -3790 1240 -3790 {lab=#net18}
N 1240 -3790 1250 -3780 {lab=#net18}
N 1250 -3780 1360 -3780 {lab=#net18}
N 1360 -3840 1370 -3850 {lab=row_n[9]}
N 1370 -3850 1570 -3850 {lab=row_n[9]}
N 1570 -3850 1580 -3840 {lab=row_n[9]}
N 1580 -3840 1710 -3840 {lab=row_n[9]}
N 1360 -3820 1370 -3830 {lab=rowon_n[9]}
N 1370 -3830 1570 -3830 {lab=rowon_n[9]}
N 1570 -3830 1580 -3820 {lab=rowon_n[9]}
N 1580 -3820 1710 -3820 {lab=rowon_n[9]}
N 1360 -3800 1370 -3810 {lab=#net17}
N 1370 -3810 1570 -3810 {lab=#net17}
N 1570 -3810 1580 -3800 {lab=#net17}
N 1580 -3800 1710 -3800 {lab=#net17}
N 1360 -3780 1380 -3790 {lab=#net18}
N 1380 -3790 1570 -3790 {lab=#net18}
N 1570 -3790 1580 -3780 {lab=#net18}
N 1580 -3780 1710 -3780 {lab=#net18}
N 1360 -3860 1370 -3870 {lab=rowoff_n[9]}
N 1370 -3870 1570 -3870 {lab=rowoff_n[9]}
N 1570 -3870 1580 -3860 {lab=rowoff_n[9]}
N 1580 -3860 1710 -3860 {lab=rowoff_n[9]}
N 1710 -3860 1720 -3870 {lab=rowoff_n[9]}
N 1720 -3870 1920 -3870 {lab=rowoff_n[9]}
N 1920 -3870 1930 -3860 {lab=rowoff_n[9]}
N 1930 -3860 2060 -3860 {lab=rowoff_n[9]}
N 1710 -3840 1720 -3850 {lab=row_n[9]}
N 1720 -3850 1920 -3850 {lab=row_n[9]}
N 1920 -3850 1930 -3840 {lab=row_n[9]}
N 1930 -3840 2060 -3840 {lab=row_n[9]}
N 1710 -3820 1720 -3830 {lab=rowon_n[9]}
N 1720 -3830 1920 -3830 {lab=rowon_n[9]}
N 1920 -3830 1930 -3820 {lab=rowon_n[9]}
N 1930 -3820 2060 -3820 {lab=rowon_n[9]}
N 1710 -3800 1720 -3810 {lab=#net17}
N 1720 -3810 1920 -3810 {lab=#net17}
N 1920 -3810 1930 -3800 {lab=#net17}
N 1930 -3800 2060 -3800 {lab=#net17}
N 1710 -3780 1720 -3790 {lab=#net18}
N 1720 -3790 1920 -3790 {lab=#net18}
N 1920 -3790 1930 -3780 {lab=#net18}
N 1930 -3780 2060 -3780 {lab=#net18}
N 2060 -3860 2070 -3870 {lab=rowoff_n[9]}
N 2070 -3870 2270 -3870 {lab=rowoff_n[9]}
N 2270 -3870 2280 -3860 {lab=rowoff_n[9]}
N 2280 -3860 2410 -3860 {lab=rowoff_n[9]}
N 2060 -3840 2070 -3850 {lab=row_n[9]}
N 2070 -3850 2270 -3850 {lab=row_n[9]}
N 2270 -3850 2280 -3840 {lab=row_n[9]}
N 2280 -3840 2410 -3840 {lab=row_n[9]}
N 2060 -3820 2070 -3830 {lab=rowon_n[9]}
N 2070 -3830 2270 -3830 {lab=rowon_n[9]}
N 2270 -3830 2280 -3820 {lab=rowon_n[9]}
N 2280 -3820 2410 -3820 {lab=rowon_n[9]}
N 2270 -3810 2280 -3800 {lab=#net17}
N 2280 -3800 2410 -3800 {lab=#net17}
N 2060 -3780 2070 -3790 {lab=#net18}
N 2070 -3790 2270 -3790 {lab=#net18}
N 2270 -3790 2280 -3780 {lab=#net18}
N 2280 -3780 2410 -3780 {lab=#net18}
N 2060 -3800 2070 -3810 {lab=#net17}
N 2070 -3810 2270 -3810 {lab=#net17}
N 2410 -3860 2420 -3870 {lab=rowoff_n[9]}
N 2420 -3870 2620 -3870 {lab=rowoff_n[9]}
N 2620 -3870 2630 -3860 {lab=rowoff_n[9]}
N 2630 -3860 2750 -3860 {lab=rowoff_n[9]}
N 2410 -3840 2420 -3850 {lab=row_n[9]}
N 2420 -3850 2620 -3850 {lab=row_n[9]}
N 2620 -3850 2630 -3840 {lab=row_n[9]}
N 2630 -3840 2750 -3840 {lab=row_n[9]}
N 2410 -3820 2420 -3830 {lab=rowon_n[9]}
N 2420 -3830 2620 -3830 {lab=rowon_n[9]}
N 2620 -3830 2630 -3820 {lab=rowon_n[9]}
N 2630 -3820 2750 -3820 {lab=rowon_n[9]}
N 2410 -3800 2420 -3810 {lab=#net17}
N 2420 -3810 2620 -3810 {lab=#net17}
N 2620 -3810 2630 -3800 {lab=#net17}
N 2630 -3800 2750 -3800 {lab=#net17}
N 2410 -3780 2420 -3790 {lab=#net18}
N 2420 -3790 2620 -3790 {lab=#net18}
N 2620 -3790 2630 -3780 {lab=#net18}
N 2630 -3780 2750 -3780 {lab=#net18}
N 2750 -3860 2760 -3870 {lab=rowoff_n[9]}
N 2760 -3870 2960 -3870 {lab=rowoff_n[9]}
N 2960 -3870 2970 -3860 {lab=rowoff_n[9]}
N 2970 -3860 3100 -3860 {lab=rowoff_n[9]}
N 2750 -3840 2760 -3850 {lab=row_n[9]}
N 2760 -3850 2960 -3850 {lab=row_n[9]}
N 2960 -3850 2970 -3840 {lab=row_n[9]}
N 2970 -3840 3100 -3840 {lab=row_n[9]}
N 2750 -3820 2760 -3830 {lab=rowon_n[9]}
N 2760 -3830 2960 -3830 {lab=rowon_n[9]}
N 2960 -3830 2970 -3820 {lab=rowon_n[9]}
N 2970 -3820 3100 -3820 {lab=rowon_n[9]}
N 2750 -3800 2760 -3810 {lab=#net17}
N 2760 -3810 2960 -3810 {lab=#net17}
N 2750 -3780 2760 -3790 {lab=#net18}
N 2760 -3790 2960 -3790 {lab=#net18}
N 2960 -3790 2970 -3780 {lab=#net18}
N 2970 -3780 3100 -3780 {lab=#net18}
N 2960 -3810 2970 -3800 {lab=#net17}
N 2970 -3800 3100 -3800 {lab=#net17}
N 3100 -3860 3110 -3870 {lab=rowoff_n[9]}
N 3110 -3870 3310 -3870 {lab=rowoff_n[9]}
N 3310 -3870 3320 -3860 {lab=rowoff_n[9]}
N 3320 -3860 3460 -3860 {lab=rowoff_n[9]}
N 3100 -3840 3110 -3850 {lab=row_n[9]}
N 3110 -3850 3310 -3850 {lab=row_n[9]}
N 3310 -3850 3320 -3840 {lab=row_n[9]}
N 3320 -3840 3460 -3840 {lab=row_n[9]}
N 3100 -3820 3110 -3830 {lab=rowon_n[9]}
N 3110 -3830 3310 -3830 {lab=rowon_n[9]}
N 3310 -3830 3320 -3820 {lab=rowon_n[9]}
N 3320 -3820 3460 -3820 {lab=rowon_n[9]}
N 3100 -3800 3110 -3810 {lab=#net17}
N 3110 -3810 3310 -3810 {lab=#net17}
N 3310 -3810 3320 -3800 {lab=#net17}
N 3320 -3800 3460 -3800 {lab=#net17}
N 3100 -3780 3110 -3790 {lab=#net18}
N 3110 -3790 3310 -3790 {lab=#net18}
N 3310 -3790 3320 -3780 {lab=#net18}
N 3320 -3780 3460 -3780 {lab=#net18}
N 3460 -3860 3470 -3870 {lab=rowoff_n[9]}
N 3470 -3870 3670 -3870 {lab=rowoff_n[9]}
N 3670 -3870 3680 -3860 {lab=rowoff_n[9]}
N 3680 -3860 3790 -3860 {lab=rowoff_n[9]}
N 3460 -3840 3470 -3850 {lab=row_n[9]}
N 3470 -3850 3670 -3850 {lab=row_n[9]}
N 3670 -3850 3680 -3840 {lab=row_n[9]}
N 3680 -3840 3790 -3840 {lab=row_n[9]}
N 3460 -3820 3470 -3830 {lab=rowon_n[9]}
N 3470 -3830 3670 -3830 {lab=rowon_n[9]}
N 3670 -3830 3680 -3820 {lab=rowon_n[9]}
N 3680 -3820 3790 -3820 {lab=rowon_n[9]}
N 3460 -3800 3470 -3810 {lab=#net17}
N 3470 -3810 3670 -3810 {lab=#net17}
N 3670 -3810 3680 -3800 {lab=#net17}
N 3680 -3800 3790 -3800 {lab=#net17}
N 3460 -3780 3470 -3790 {lab=#net18}
N 3470 -3790 3670 -3790 {lab=#net18}
N 3670 -3790 3680 -3780 {lab=#net18}
N 3680 -3780 3790 -3780 {lab=#net18}
N 3790 -3860 3800 -3870 {lab=rowoff_n[9]}
N 3800 -3870 4000 -3870 {lab=rowoff_n[9]}
N 4000 -3870 4010 -3860 {lab=rowoff_n[9]}
N 4010 -3860 4120 -3860 {lab=rowoff_n[9]}
N 3790 -3840 3800 -3850 {lab=row_n[9]}
N 3800 -3850 4000 -3850 {lab=row_n[9]}
N 4000 -3850 4010 -3840 {lab=row_n[9]}
N 4010 -3840 4120 -3840 {lab=row_n[9]}
N 3790 -3820 3800 -3830 {lab=rowon_n[9]}
N 3800 -3830 4000 -3830 {lab=rowon_n[9]}
N 4000 -3830 4010 -3820 {lab=rowon_n[9]}
N 4010 -3820 4120 -3820 {lab=rowon_n[9]}
N 3790 -3800 3800 -3810 {lab=#net17}
N 3800 -3810 4000 -3810 {lab=#net17}
N 4000 -3810 4010 -3800 {lab=#net17}
N 4010 -3800 4120 -3800 {lab=#net17}
N 3790 -3780 3800 -3790 {lab=#net18}
N 3800 -3790 4000 -3790 {lab=#net18}
N 4000 -3790 4020 -3780 {lab=#net18}
N 4020 -3780 4120 -3780 {lab=#net18}
N 4120 -3860 4130 -3870 {lab=rowoff_n[9]}
N 4130 -3870 4330 -3870 {lab=rowoff_n[9]}
N 4330 -3870 4340 -3860 {lab=rowoff_n[9]}
N 4340 -3860 4470 -3860 {lab=rowoff_n[9]}
N 4120 -3840 4130 -3850 {lab=row_n[9]}
N 4130 -3850 4330 -3850 {lab=row_n[9]}
N 4330 -3850 4340 -3840 {lab=row_n[9]}
N 4340 -3840 4470 -3840 {lab=row_n[9]}
N 4120 -3820 4130 -3830 {lab=rowon_n[9]}
N 4130 -3830 4330 -3830 {lab=rowon_n[9]}
N 4330 -3830 4340 -3820 {lab=rowon_n[9]}
N 4340 -3820 4470 -3820 {lab=rowon_n[9]}
N 4120 -3800 4130 -3810 {lab=#net17}
N 4130 -3810 4330 -3810 {lab=#net17}
N 4330 -3810 4340 -3800 {lab=#net17}
N 4340 -3800 4470 -3800 {lab=#net17}
N 4120 -3780 4130 -3790 {lab=#net18}
N 4130 -3790 4330 -3790 {lab=#net18}
N 4330 -3790 4340 -3780 {lab=#net18}
N 4340 -3780 4470 -3780 {lab=#net18}
N 4470 -3860 4480 -3870 {lab=rowoff_n[9]}
N 4480 -3870 4680 -3870 {lab=rowoff_n[9]}
N 4680 -3870 4690 -3860 {lab=rowoff_n[9]}
N 4690 -3860 4820 -3860 {lab=rowoff_n[9]}
N 4470 -3840 4480 -3850 {lab=row_n[9]}
N 4480 -3850 4680 -3850 {lab=row_n[9]}
N 4470 -3820 4480 -3830 {lab=rowon_n[9]}
N 4480 -3830 4680 -3830 {lab=rowon_n[9]}
N 4680 -3830 4690 -3820 {lab=rowon_n[9]}
N 4690 -3820 4820 -3820 {lab=rowon_n[9]}
N 4680 -3850 4690 -3840 {lab=row_n[9]}
N 4690 -3840 4820 -3840 {lab=row_n[9]}
N 4470 -3800 4480 -3810 {lab=#net17}
N 4480 -3810 4680 -3810 {lab=#net17}
N 4680 -3810 4690 -3800 {lab=#net17}
N 4690 -3800 4820 -3800 {lab=#net17}
N 4470 -3780 4480 -3790 {lab=#net18}
N 4480 -3790 4680 -3790 {lab=#net18}
N 4680 -3790 4690 -3780 {lab=#net18}
N 4690 -3780 4820 -3780 {lab=#net18}
N 4820 -3860 4830 -3870 {lab=rowoff_n[9]}
N 4830 -3870 5030 -3870 {lab=rowoff_n[9]}
N 5030 -3870 5040 -3860 {lab=rowoff_n[9]}
N 5040 -3860 5160 -3860 {lab=rowoff_n[9]}
N 4820 -3840 4830 -3850 {lab=row_n[9]}
N 4830 -3850 5030 -3850 {lab=row_n[9]}
N 5030 -3850 5040 -3840 {lab=row_n[9]}
N 5040 -3840 5160 -3840 {lab=row_n[9]}
N 4820 -3820 4830 -3830 {lab=rowon_n[9]}
N 4830 -3830 5030 -3830 {lab=rowon_n[9]}
N 5030 -3830 5040 -3820 {lab=rowon_n[9]}
N 5040 -3820 5160 -3820 {lab=rowon_n[9]}
N 4820 -3800 4830 -3810 {lab=#net17}
N 4830 -3810 5030 -3810 {lab=#net17}
N 5030 -3810 5040 -3800 {lab=#net17}
N 5040 -3800 5160 -3800 {lab=#net17}
N 4820 -3780 4830 -3790 {lab=#net18}
N 4830 -3790 5030 -3790 {lab=#net18}
N 5030 -3790 5040 -3780 {lab=#net18}
N 5040 -3780 5160 -3780 {lab=#net18}
N 5160 -3860 5170 -3870 {lab=rowoff_n[9]}
N 5170 -3870 5370 -3870 {lab=rowoff_n[9]}
N 5370 -3870 5380 -3860 {lab=rowoff_n[9]}
N 5380 -3860 5500 -3860 {lab=rowoff_n[9]}
N 5160 -3840 5170 -3850 {lab=row_n[9]}
N 5170 -3850 5370 -3850 {lab=row_n[9]}
N 5370 -3850 5380 -3840 {lab=row_n[9]}
N 5380 -3840 5500 -3840 {lab=row_n[9]}
N 5160 -3820 5170 -3830 {lab=rowon_n[9]}
N 5170 -3830 5370 -3830 {lab=rowon_n[9]}
N 5370 -3830 5380 -3820 {lab=rowon_n[9]}
N 5380 -3820 5500 -3820 {lab=rowon_n[9]}
N 5160 -3800 5170 -3810 {lab=#net17}
N 5170 -3810 5370 -3810 {lab=#net17}
N 5370 -3810 5380 -3800 {lab=#net17}
N 5380 -3800 5500 -3800 {lab=#net17}
N 5160 -3780 5170 -3790 {lab=#net18}
N 5170 -3790 5370 -3790 {lab=#net18}
N 5370 -3790 5390 -3780 {lab=#net18}
N 5390 -3780 5500 -3780 {lab=#net18}
N 5500 -3860 5510 -3870 {lab=rowoff_n[9]}
N 5510 -3870 5710 -3870 {lab=rowoff_n[9]}
N 5500 -3840 5510 -3850 {lab=row_n[9]}
N 5510 -3850 5710 -3850 {lab=row_n[9]}
N 5710 -3850 5720 -3840 {lab=row_n[9]}
N 5710 -3870 5720 -3860 {lab=rowoff_n[9]}
N 5500 -3820 5510 -3830 {lab=rowon_n[9]}
N 5510 -3830 5710 -3830 {lab=rowon_n[9]}
N 5500 -3800 5510 -3810 {lab=#net17}
N 5510 -3810 5710 -3810 {lab=#net17}
N 5710 -3810 5720 -3800 {lab=#net17}
N 5500 -3780 5510 -3790 {lab=#net18}
N 5510 -3790 5710 -3790 {lab=#net18}
N 5710 -3790 5720 -3780 {lab=#net18}
N 5710 -3830 5720 -3820 {lab=rowon_n[9]}
N 750 -4030 750 -4020 {
lab=VSS}
N 1070 -4030 1070 -4020 {
lab=VSS}
N 1400 -4030 1400 -4020 {
lab=VSS}
N 1750 -4030 1750 -4020 {
lab=VSS}
N 2100 -4030 2100 -4020 {
lab=VSS}
N 2450 -4030 2450 -4020 {
lab=VSS}
N 2790 -4030 2790 -4020 {
lab=VSS}
N 3140 -4030 3140 -4020 {
lab=VSS}
N 3500 -4030 3500 -4020 {
lab=VSS}
N 3830 -4030 3830 -4020 {
lab=VSS}
N 4160 -4030 4160 -4020 {
lab=VSS}
N 4510 -4030 4510 -4020 {
lab=VSS}
N 4860 -4030 4860 -4020 {
lab=VSS}
N 5200 -4030 5200 -4020 {
lab=VSS}
N 5540 -4030 5540 -4020 {
lab=VSS}
N 5560 -4270 5560 -4250 {
lab=vcm}
N 5540 -4260 5540 -4250 {
lab=VDD}
N 5600 -4270 5600 -4250 {
lab=ctop}
N 4880 -4270 4880 -4250 {
lab=vcm}
N 4860 -4260 4860 -4250 {
lab=VDD}
N 4920 -4270 4920 -4250 {
lab=ctop}
N 5220 -4270 5220 -4250 {
lab=vcm}
N 5200 -4260 5200 -4250 {
lab=VDD}
N 5260 -4270 5260 -4250 {
lab=ctop}
N 4530 -4270 4530 -4250 {
lab=vcm}
N 4510 -4260 4510 -4250 {
lab=VDD}
N 4570 -4270 4570 -4250 {
lab=ctop}
N 4180 -4270 4180 -4250 {
lab=vcm}
N 4160 -4260 4160 -4250 {
lab=VDD}
N 4220 -4270 4220 -4250 {
lab=ctop}
N 3850 -4270 3850 -4250 {
lab=vcm}
N 3830 -4260 3830 -4250 {
lab=VDD}
N 3890 -4270 3890 -4250 {
lab=ctop}
N 3520 -4270 3520 -4250 {
lab=vcm}
N 3500 -4260 3500 -4250 {
lab=VDD}
N 3560 -4270 3560 -4250 {
lab=ctop}
N 3160 -4270 3160 -4250 {
lab=vcm}
N 3140 -4260 3140 -4250 {
lab=VDD}
N 3200 -4270 3200 -4250 {
lab=ctop}
N 2810 -4270 2810 -4250 {
lab=vcm}
N 2790 -4260 2790 -4250 {
lab=VDD}
N 2850 -4270 2850 -4250 {
lab=ctop}
N 2470 -4270 2470 -4250 {
lab=vcm}
N 2450 -4260 2450 -4250 {
lab=VDD}
N 2510 -4270 2510 -4250 {
lab=ctop}
N 2120 -4270 2120 -4250 {
lab=vcm}
N 2100 -4260 2100 -4250 {
lab=VDD}
N 2160 -4270 2160 -4250 {
lab=ctop}
N 1770 -4270 1770 -4250 {
lab=vcm}
N 1750 -4260 1750 -4250 {
lab=VDD}
N 1810 -4270 1810 -4250 {
lab=ctop}
N 1420 -4270 1420 -4250 {
lab=vcm}
N 1400 -4260 1400 -4250 {
lab=VDD}
N 1460 -4270 1460 -4250 {
lab=ctop}
N 1090 -4270 1090 -4250 {
lab=vcm}
N 1070 -4260 1070 -4250 {
lab=VDD}
N 1130 -4270 1130 -4250 {
lab=ctop}
N 770 -4270 770 -4250 {
lab=vcm}
N 750 -4260 750 -4250 {
lab=VDD}
N 810 -4270 810 -4250 {
lab=ctop}
N 690 -4110 710 -4110 {
lab=sample_n}
N 690 -4130 710 -4130 {
lab=sample}
N 690 -4150 710 -4150 {
lab=VDD}
N 690 -4170 710 -4170 {
lab=VDD}
N 690 -4190 710 -4190 {
lab=VSS}
N 930 -4130 1030 -4130 {lab=#net19}
N 930 -4110 1030 -4110 {lab=#net20}
N 710 -4190 720 -4200 {lab=VSS}
N 720 -4200 940 -4200 {lab=VSS}
N 940 -4200 950 -4190 {lab=VSS}
N 950 -4190 1030 -4190 {lab=VSS}
N 710 -4170 720 -4180 {lab=VDD}
N 720 -4180 940 -4180 {lab=VDD}
N 940 -4180 950 -4170 {lab=VDD}
N 950 -4170 1030 -4170 {lab=VDD}
N 710 -4150 720 -4160 {lab=VDD}
N 720 -4160 940 -4160 {lab=VDD}
N 940 -4160 950 -4150 {lab=VDD}
N 950 -4150 1030 -4150 {lab=VDD}
N 1030 -4190 1040 -4200 {lab=VSS}
N 1030 -4170 1040 -4180 {lab=VDD}
N 1040 -4180 1240 -4180 {lab=VDD}
N 1240 -4180 1250 -4170 {lab=VDD}
N 1250 -4170 1360 -4170 {lab=VDD}
N 1040 -4200 1240 -4200 {lab=VSS}
N 1240 -4200 1250 -4190 {lab=VSS}
N 1250 -4190 1360 -4190 {lab=VSS}
N 1030 -4150 1040 -4160 {lab=VDD}
N 1040 -4160 1240 -4160 {lab=VDD}
N 1240 -4160 1250 -4150 {lab=VDD}
N 1250 -4150 1360 -4150 {lab=VDD}
N 1030 -4130 1040 -4140 {lab=#net19}
N 1040 -4140 1240 -4140 {lab=#net19}
N 1240 -4140 1250 -4130 {lab=#net19}
N 1250 -4130 1360 -4130 {lab=#net19}
N 1030 -4110 1040 -4120 {lab=#net20}
N 1040 -4120 1240 -4120 {lab=#net20}
N 1240 -4120 1250 -4110 {lab=#net20}
N 1250 -4110 1360 -4110 {lab=#net20}
N 1360 -4170 1370 -4180 {lab=VDD}
N 1370 -4180 1570 -4180 {lab=VDD}
N 1570 -4180 1580 -4170 {lab=VDD}
N 1580 -4170 1710 -4170 {lab=VDD}
N 1360 -4150 1370 -4160 {lab=VDD}
N 1370 -4160 1570 -4160 {lab=VDD}
N 1570 -4160 1580 -4150 {lab=VDD}
N 1580 -4150 1710 -4150 {lab=VDD}
N 1360 -4130 1370 -4140 {lab=#net19}
N 1370 -4140 1570 -4140 {lab=#net19}
N 1570 -4140 1580 -4130 {lab=#net19}
N 1580 -4130 1710 -4130 {lab=#net19}
N 1360 -4110 1380 -4120 {lab=#net20}
N 1380 -4120 1570 -4120 {lab=#net20}
N 1570 -4120 1580 -4110 {lab=#net20}
N 1580 -4110 1710 -4110 {lab=#net20}
N 1360 -4190 1370 -4200 {lab=VSS}
N 1370 -4200 1570 -4200 {lab=VSS}
N 1570 -4200 1580 -4190 {lab=VSS}
N 1580 -4190 1710 -4190 {lab=VSS}
N 1710 -4190 1720 -4200 {lab=VSS}
N 1720 -4200 1920 -4200 {lab=VSS}
N 1920 -4200 1930 -4190 {lab=VSS}
N 1930 -4190 2060 -4190 {lab=VSS}
N 1710 -4170 1720 -4180 {lab=VDD}
N 1720 -4180 1920 -4180 {lab=VDD}
N 1920 -4180 1930 -4170 {lab=VDD}
N 1930 -4170 2060 -4170 {lab=VDD}
N 1710 -4150 1720 -4160 {lab=VDD}
N 1720 -4160 1920 -4160 {lab=VDD}
N 1920 -4160 1930 -4150 {lab=VDD}
N 1930 -4150 2060 -4150 {lab=VDD}
N 1710 -4130 1720 -4140 {lab=#net19}
N 1720 -4140 1920 -4140 {lab=#net19}
N 1920 -4140 1930 -4130 {lab=#net19}
N 1930 -4130 2060 -4130 {lab=#net19}
N 1710 -4110 1720 -4120 {lab=#net20}
N 1720 -4120 1920 -4120 {lab=#net20}
N 1920 -4120 1930 -4110 {lab=#net20}
N 1930 -4110 2060 -4110 {lab=#net20}
N 2060 -4190 2070 -4200 {lab=VSS}
N 2070 -4200 2270 -4200 {lab=VSS}
N 2270 -4200 2280 -4190 {lab=VSS}
N 2280 -4190 2410 -4190 {lab=VSS}
N 2060 -4170 2070 -4180 {lab=VDD}
N 2070 -4180 2270 -4180 {lab=VDD}
N 2270 -4180 2280 -4170 {lab=VDD}
N 2280 -4170 2410 -4170 {lab=VDD}
N 2060 -4150 2070 -4160 {lab=VDD}
N 2070 -4160 2270 -4160 {lab=VDD}
N 2270 -4160 2280 -4150 {lab=VDD}
N 2280 -4150 2410 -4150 {lab=VDD}
N 2270 -4140 2280 -4130 {lab=#net19}
N 2280 -4130 2410 -4130 {lab=#net19}
N 2060 -4110 2070 -4120 {lab=#net20}
N 2070 -4120 2270 -4120 {lab=#net20}
N 2270 -4120 2280 -4110 {lab=#net20}
N 2280 -4110 2410 -4110 {lab=#net20}
N 2060 -4130 2070 -4140 {lab=#net19}
N 2070 -4140 2270 -4140 {lab=#net19}
N 2410 -4190 2420 -4200 {lab=VSS}
N 2420 -4200 2620 -4200 {lab=VSS}
N 2620 -4200 2630 -4190 {lab=VSS}
N 2630 -4190 2750 -4190 {lab=VSS}
N 2410 -4170 2420 -4180 {lab=VDD}
N 2420 -4180 2620 -4180 {lab=VDD}
N 2620 -4180 2630 -4170 {lab=VDD}
N 2630 -4170 2750 -4170 {lab=VDD}
N 2410 -4150 2420 -4160 {lab=VDD}
N 2420 -4160 2620 -4160 {lab=VDD}
N 2620 -4160 2630 -4150 {lab=VDD}
N 2630 -4150 2750 -4150 {lab=VDD}
N 2410 -4130 2420 -4140 {lab=#net19}
N 2420 -4140 2620 -4140 {lab=#net19}
N 2620 -4140 2630 -4130 {lab=#net19}
N 2630 -4130 2750 -4130 {lab=#net19}
N 2410 -4110 2420 -4120 {lab=#net20}
N 2420 -4120 2620 -4120 {lab=#net20}
N 2620 -4120 2630 -4110 {lab=#net20}
N 2630 -4110 2750 -4110 {lab=#net20}
N 2750 -4190 2760 -4200 {lab=VSS}
N 2760 -4200 2960 -4200 {lab=VSS}
N 2960 -4200 2970 -4190 {lab=VSS}
N 2970 -4190 3100 -4190 {lab=VSS}
N 2750 -4170 2760 -4180 {lab=VDD}
N 2760 -4180 2960 -4180 {lab=VDD}
N 2960 -4180 2970 -4170 {lab=VDD}
N 2970 -4170 3100 -4170 {lab=VDD}
N 2750 -4150 2760 -4160 {lab=VDD}
N 2760 -4160 2960 -4160 {lab=VDD}
N 2960 -4160 2970 -4150 {lab=VDD}
N 2970 -4150 3100 -4150 {lab=VDD}
N 2750 -4130 2760 -4140 {lab=#net19}
N 2760 -4140 2960 -4140 {lab=#net19}
N 2750 -4110 2760 -4120 {lab=#net20}
N 2760 -4120 2960 -4120 {lab=#net20}
N 2960 -4120 2970 -4110 {lab=#net20}
N 2970 -4110 3100 -4110 {lab=#net20}
N 2960 -4140 2970 -4130 {lab=#net19}
N 2970 -4130 3100 -4130 {lab=#net19}
N 3100 -4190 3110 -4200 {lab=VSS}
N 3110 -4200 3310 -4200 {lab=VSS}
N 3310 -4200 3320 -4190 {lab=VSS}
N 3320 -4190 3460 -4190 {lab=VSS}
N 3100 -4170 3110 -4180 {lab=VDD}
N 3110 -4180 3310 -4180 {lab=VDD}
N 3310 -4180 3320 -4170 {lab=VDD}
N 3320 -4170 3460 -4170 {lab=VDD}
N 3100 -4150 3110 -4160 {lab=VDD}
N 3110 -4160 3310 -4160 {lab=VDD}
N 3310 -4160 3320 -4150 {lab=VDD}
N 3320 -4150 3460 -4150 {lab=VDD}
N 3100 -4130 3110 -4140 {lab=#net19}
N 3110 -4140 3310 -4140 {lab=#net19}
N 3310 -4140 3320 -4130 {lab=#net19}
N 3320 -4130 3460 -4130 {lab=#net19}
N 3100 -4110 3110 -4120 {lab=#net20}
N 3110 -4120 3310 -4120 {lab=#net20}
N 3310 -4120 3320 -4110 {lab=#net20}
N 3320 -4110 3460 -4110 {lab=#net20}
N 3460 -4190 3470 -4200 {lab=VSS}
N 3470 -4200 3670 -4200 {lab=VSS}
N 3670 -4200 3680 -4190 {lab=VSS}
N 3680 -4190 3790 -4190 {lab=VSS}
N 3460 -4170 3470 -4180 {lab=VDD}
N 3470 -4180 3670 -4180 {lab=VDD}
N 3670 -4180 3680 -4170 {lab=VDD}
N 3680 -4170 3790 -4170 {lab=VDD}
N 3460 -4150 3470 -4160 {lab=VDD}
N 3470 -4160 3670 -4160 {lab=VDD}
N 3670 -4160 3680 -4150 {lab=VDD}
N 3680 -4150 3790 -4150 {lab=VDD}
N 3460 -4130 3470 -4140 {lab=#net19}
N 3470 -4140 3670 -4140 {lab=#net19}
N 3670 -4140 3680 -4130 {lab=#net19}
N 3680 -4130 3790 -4130 {lab=#net19}
N 3460 -4110 3470 -4120 {lab=#net20}
N 3470 -4120 3670 -4120 {lab=#net20}
N 3670 -4120 3680 -4110 {lab=#net20}
N 3680 -4110 3790 -4110 {lab=#net20}
N 3790 -4190 3800 -4200 {lab=VSS}
N 3800 -4200 4000 -4200 {lab=VSS}
N 4000 -4200 4010 -4190 {lab=VSS}
N 4010 -4190 4120 -4190 {lab=VSS}
N 3790 -4170 3800 -4180 {lab=VDD}
N 3800 -4180 4000 -4180 {lab=VDD}
N 4000 -4180 4010 -4170 {lab=VDD}
N 4010 -4170 4120 -4170 {lab=VDD}
N 3790 -4150 3800 -4160 {lab=VDD}
N 3800 -4160 4000 -4160 {lab=VDD}
N 4000 -4160 4010 -4150 {lab=VDD}
N 4010 -4150 4120 -4150 {lab=VDD}
N 3790 -4130 3800 -4140 {lab=#net19}
N 3800 -4140 4000 -4140 {lab=#net19}
N 4000 -4140 4010 -4130 {lab=#net19}
N 4010 -4130 4120 -4130 {lab=#net19}
N 3790 -4110 3800 -4120 {lab=#net20}
N 3800 -4120 4000 -4120 {lab=#net20}
N 4000 -4120 4020 -4110 {lab=#net20}
N 4020 -4110 4120 -4110 {lab=#net20}
N 4120 -4190 4130 -4200 {lab=VSS}
N 4130 -4200 4330 -4200 {lab=VSS}
N 4330 -4200 4340 -4190 {lab=VSS}
N 4340 -4190 4470 -4190 {lab=VSS}
N 4120 -4170 4130 -4180 {lab=VDD}
N 4130 -4180 4330 -4180 {lab=VDD}
N 4330 -4180 4340 -4170 {lab=VDD}
N 4340 -4170 4470 -4170 {lab=VDD}
N 4120 -4150 4130 -4160 {lab=VDD}
N 4130 -4160 4330 -4160 {lab=VDD}
N 4330 -4160 4340 -4150 {lab=VDD}
N 4340 -4150 4470 -4150 {lab=VDD}
N 4120 -4130 4130 -4140 {lab=#net19}
N 4130 -4140 4330 -4140 {lab=#net19}
N 4330 -4140 4340 -4130 {lab=#net19}
N 4340 -4130 4470 -4130 {lab=#net19}
N 4120 -4110 4130 -4120 {lab=#net20}
N 4130 -4120 4330 -4120 {lab=#net20}
N 4330 -4120 4340 -4110 {lab=#net20}
N 4340 -4110 4470 -4110 {lab=#net20}
N 4470 -4190 4480 -4200 {lab=VSS}
N 4480 -4200 4680 -4200 {lab=VSS}
N 4680 -4200 4690 -4190 {lab=VSS}
N 4690 -4190 4820 -4190 {lab=VSS}
N 4470 -4170 4480 -4180 {lab=VDD}
N 4480 -4180 4680 -4180 {lab=VDD}
N 4470 -4150 4480 -4160 {lab=VDD}
N 4480 -4160 4680 -4160 {lab=VDD}
N 4680 -4160 4690 -4150 {lab=VDD}
N 4690 -4150 4820 -4150 {lab=VDD}
N 4680 -4180 4690 -4170 {lab=VDD}
N 4690 -4170 4820 -4170 {lab=VDD}
N 4470 -4130 4480 -4140 {lab=#net19}
N 4480 -4140 4680 -4140 {lab=#net19}
N 4680 -4140 4690 -4130 {lab=#net19}
N 4690 -4130 4820 -4130 {lab=#net19}
N 4470 -4110 4480 -4120 {lab=#net20}
N 4480 -4120 4680 -4120 {lab=#net20}
N 4680 -4120 4690 -4110 {lab=#net20}
N 4690 -4110 4820 -4110 {lab=#net20}
N 4820 -4190 4830 -4200 {lab=VSS}
N 4830 -4200 5030 -4200 {lab=VSS}
N 5030 -4200 5040 -4190 {lab=VSS}
N 5040 -4190 5160 -4190 {lab=VSS}
N 4820 -4170 4830 -4180 {lab=VDD}
N 4830 -4180 5030 -4180 {lab=VDD}
N 5030 -4180 5040 -4170 {lab=VDD}
N 5040 -4170 5160 -4170 {lab=VDD}
N 4820 -4150 4830 -4160 {lab=VDD}
N 4830 -4160 5030 -4160 {lab=VDD}
N 5030 -4160 5040 -4150 {lab=VDD}
N 5040 -4150 5160 -4150 {lab=VDD}
N 4820 -4130 4830 -4140 {lab=#net19}
N 4830 -4140 5030 -4140 {lab=#net19}
N 5030 -4140 5040 -4130 {lab=#net19}
N 5040 -4130 5160 -4130 {lab=#net19}
N 4820 -4110 4830 -4120 {lab=#net20}
N 4830 -4120 5030 -4120 {lab=#net20}
N 5030 -4120 5040 -4110 {lab=#net20}
N 5040 -4110 5160 -4110 {lab=#net20}
N 5160 -4190 5170 -4200 {lab=VSS}
N 5170 -4200 5370 -4200 {lab=VSS}
N 5370 -4200 5380 -4190 {lab=VSS}
N 5380 -4190 5500 -4190 {lab=VSS}
N 5160 -4170 5170 -4180 {lab=VDD}
N 5170 -4180 5370 -4180 {lab=VDD}
N 5370 -4180 5380 -4170 {lab=VDD}
N 5380 -4170 5500 -4170 {lab=VDD}
N 5160 -4150 5170 -4160 {lab=VDD}
N 5170 -4160 5370 -4160 {lab=VDD}
N 5370 -4160 5380 -4150 {lab=VDD}
N 5380 -4150 5500 -4150 {lab=VDD}
N 5160 -4130 5170 -4140 {lab=#net19}
N 5170 -4140 5370 -4140 {lab=#net19}
N 5370 -4140 5380 -4130 {lab=#net19}
N 5380 -4130 5500 -4130 {lab=#net19}
N 5160 -4110 5170 -4120 {lab=#net20}
N 5170 -4120 5370 -4120 {lab=#net20}
N 5370 -4120 5390 -4110 {lab=#net20}
N 5390 -4110 5500 -4110 {lab=#net20}
N 5500 -4190 5510 -4200 {lab=VSS}
N 5510 -4200 5710 -4200 {lab=VSS}
N 5500 -4170 5510 -4180 {lab=VDD}
N 5510 -4180 5710 -4180 {lab=VDD}
N 5710 -4180 5720 -4170 {lab=VDD}
N 5710 -4200 5720 -4190 {lab=VSS}
N 5500 -4150 5510 -4160 {lab=VDD}
N 5510 -4160 5710 -4160 {lab=VDD}
N 5500 -4130 5510 -4140 {lab=#net19}
N 5510 -4140 5710 -4140 {lab=#net19}
N 5710 -4140 5720 -4130 {lab=#net19}
N 5500 -4110 5510 -4120 {lab=#net20}
N 5510 -4120 5710 -4120 {lab=#net20}
N 5710 -4120 5720 -4110 {lab=#net20}
N 5710 -4160 5720 -4150 {lab=VDD}
N 830 -3700 840 -3710 {lab=VDD}
N 840 -3960 840 -3710 {lab=VDD}
N 830 -3970 840 -3960 {lab=VDD}
N 830 -4030 830 -3970 {lab=VDD}
N 850 -4030 850 -3970 {lab=VSS}
N 850 -3970 860 -3960 {lab=VSS}
N 860 -3960 860 -3710 {lab=VSS}
N 850 -3700 860 -3710 {lab=VSS}
N 1160 -3960 1160 -3710 {lab=col_n[0]}
N 1150 -3970 1160 -3960 {lab=col_n[0]}
N 1150 -4030 1150 -3970 {lab=col_n[0]}
N 1170 -4030 1170 -3970 {lab=col[0]}
N 1170 -3970 1180 -3960 {lab=col[0]}
N 1180 -3960 1180 -3710 {lab=col[0]}
N 1490 -3960 1490 -3710 {lab=col_n[1]}
N 1480 -3970 1490 -3960 {lab=col_n[1]}
N 1480 -4030 1480 -3970 {lab=col_n[1]}
N 1500 -4030 1500 -3970 {lab=col[1]}
N 1500 -3970 1510 -3960 {lab=col[1]}
N 1510 -3960 1510 -3710 {lab=col[1]}
N 1840 -3960 1840 -3710 {lab=col_n[2]}
N 1830 -3970 1840 -3960 {lab=col_n[2]}
N 1830 -4030 1830 -3970 {lab=col_n[2]}
N 1850 -4030 1850 -3970 {lab=col[2]}
N 1850 -3970 1860 -3960 {lab=col[2]}
N 1860 -3960 1860 -3710 {lab=col[2]}
N 2190 -3960 2190 -3710 {lab=col_n[3]}
N 2180 -3970 2190 -3960 {lab=col_n[3]}
N 2180 -4030 2180 -3970 {lab=col_n[3]}
N 2200 -4030 2200 -3970 {lab=col[3]}
N 2200 -3970 2210 -3960 {lab=col[3]}
N 2210 -3960 2210 -3710 {lab=col[3]}
N 2540 -3960 2540 -3710 {lab=col_n[4]}
N 2530 -3970 2540 -3960 {lab=col_n[4]}
N 2530 -4030 2530 -3970 {lab=col_n[4]}
N 2550 -4030 2550 -3970 {lab=col[4]}
N 2550 -3970 2560 -3960 {lab=col[4]}
N 2560 -3960 2560 -3710 {lab=col[4]}
N 2880 -3960 2880 -3710 {lab=col_n[5]}
N 2870 -3970 2880 -3960 {lab=col_n[5]}
N 2870 -4030 2870 -3970 {lab=col_n[5]}
N 2890 -4030 2890 -3970 {lab=col[5]}
N 2890 -3970 2900 -3960 {lab=col[5]}
N 2900 -3960 2900 -3710 {lab=col[5]}
N 3230 -3960 3230 -3710 {lab=col_n[6]}
N 3220 -3970 3230 -3960 {lab=col_n[6]}
N 3220 -4030 3220 -3970 {lab=col_n[6]}
N 3240 -4030 3240 -3970 {lab=col[6]}
N 3240 -3970 3250 -3960 {lab=col[6]}
N 3250 -3960 3250 -3710 {lab=col[6]}
N 3590 -3960 3590 -3710 {lab=col_n[7]}
N 3580 -3970 3590 -3960 {lab=col_n[7]}
N 3580 -4030 3580 -3970 {lab=col_n[7]}
N 3600 -4030 3600 -3970 {lab=col[7]}
N 3600 -3970 3610 -3960 {lab=col[7]}
N 3610 -3960 3610 -3710 {lab=col[7]}
N 3920 -3960 3920 -3710 {lab=col_n[8]}
N 3910 -3970 3920 -3960 {lab=col_n[8]}
N 3910 -4030 3910 -3970 {lab=col_n[8]}
N 3930 -4030 3930 -3970 {lab=col[8]}
N 3930 -3970 3940 -3960 {lab=col[8]}
N 3940 -3960 3940 -3710 {lab=col[8]}
N 4250 -3960 4250 -3710 {lab=col_n[9]}
N 4240 -3970 4250 -3960 {lab=col_n[9]}
N 4240 -4030 4240 -3970 {lab=col_n[9]}
N 4260 -4030 4260 -3970 {lab=col[9]}
N 4260 -3970 4270 -3960 {lab=col[9]}
N 4270 -3960 4270 -3710 {lab=col[9]}
N 4600 -3960 4600 -3710 {lab=col_n[10]}
N 4590 -3970 4600 -3960 {lab=col_n[10]}
N 4590 -4030 4590 -3970 {lab=col_n[10]}
N 4610 -4030 4610 -3970 {lab=col[10]}
N 4610 -3970 4620 -3960 {lab=col[10]}
N 4620 -3960 4620 -3710 {lab=col[10]}
N 4950 -3960 4950 -3710 {lab=col_n[11]}
N 4940 -3970 4950 -3960 {lab=col_n[11]}
N 4940 -4030 4940 -3970 {lab=col_n[11]}
N 4960 -4030 4960 -3970 {lab=col[11]}
N 4960 -3970 4970 -3960 {lab=col[11]}
N 4970 -3960 4970 -3710 {lab=col[11]}
N 5290 -3960 5290 -3710 {lab=col_n[12]}
N 5280 -3970 5290 -3960 {lab=col_n[12]}
N 5280 -4030 5280 -3970 {lab=col_n[12]}
N 5300 -4030 5300 -3970 {lab=col[12]}
N 5300 -3970 5310 -3960 {lab=col[12]}
N 5310 -3960 5310 -3710 {lab=col[12]}
N 5630 -3960 5630 -3710 {lab=VDD}
N 5620 -3970 5630 -3960 {lab=VDD}
N 5620 -4030 5620 -3970 {lab=VDD}
N 5640 -4030 5640 -3970 {lab=VSS}
N 5640 -3970 5650 -3960 {lab=VSS}
N 5650 -3960 5650 -3710 {lab=VSS}
N 5640 -3700 5650 -3710 {lab=VSS}
N 5620 -3700 5630 -3710 {lab=VDD}
N 5280 -3700 5290 -3710 {lab=col_n[12]}
N 5300 -3700 5310 -3710 {lab=col[12]}
N 4940 -3700 4950 -3710 {lab=col_n[11]}
N 4960 -3700 4970 -3710 {lab=col[11]}
N 4590 -3700 4600 -3710 {lab=col_n[10]}
N 4610 -3700 4620 -3710 {lab=col[10]}
N 4260 -3700 4270 -3710 {lab=col[9]}
N 4240 -3700 4250 -3710 {lab=col_n[9]}
N 3930 -3700 3940 -3710 {lab=col[8]}
N 3910 -3700 3920 -3710 {lab=col_n[8]}
N 3580 -3700 3590 -3710 {lab=col_n[7]}
N 3600 -3700 3610 -3710 {lab=col[7]}
N 3220 -3700 3230 -3710 {lab=col_n[6]}
N 3240 -3700 3250 -3710 {lab=col[6]}
N 2890 -3700 2900 -3710 {lab=col[5]}
N 2870 -3700 2880 -3710 {lab=col_n[5]}
N 2550 -3700 2560 -3710 {lab=col[4]}
N 2530 -3700 2540 -3710 {lab=col_n[4]}
N 2200 -3700 2210 -3710 {lab=col[3]}
N 2180 -3700 2190 -3710 {lab=col_n[3]}
N 1850 -3700 1860 -3710 {lab=col[2]}
N 1830 -3700 1840 -3710 {lab=col_n[2]}
N 1500 -3700 1510 -3710 {lab=col[1]}
N 1480 -3700 1490 -3710 {lab=col_n[1]}
N 1150 -3700 1160 -3710 {lab=col_n[0]}
N 1170 -3700 1180 -3710 {lab=col[0]}
N 830 -3390 840 -3400 {lab=VDD}
N 830 -3700 830 -3660 {lab=VDD}
N 850 -3390 860 -3400 {lab=VSS}
N 860 -3640 860 -3400 {lab=VSS}
N 850 -3650 860 -3640 {lab=VSS}
N 850 -3700 850 -3650 {lab=VSS}
N 840 -3640 840 -3400 {lab=VDD}
N 830 -3650 840 -3640 {lab=VDD}
N 830 -3660 830 -3650 {lab=VDD}
N 1150 -3700 1150 -3660 {lab=col_n[0]}
N 1180 -3640 1180 -3400 {lab=col[0]}
N 1170 -3650 1180 -3640 {lab=col[0]}
N 1170 -3700 1170 -3650 {lab=col[0]}
N 1160 -3640 1160 -3400 {lab=col_n[0]}
N 1150 -3650 1160 -3640 {lab=col_n[0]}
N 1150 -3660 1150 -3650 {lab=col_n[0]}
N 1480 -3700 1480 -3660 {lab=col_n[1]}
N 1510 -3640 1510 -3400 {lab=col[1]}
N 1500 -3650 1510 -3640 {lab=col[1]}
N 1500 -3700 1500 -3650 {lab=col[1]}
N 1490 -3640 1490 -3400 {lab=col_n[1]}
N 1480 -3650 1490 -3640 {lab=col_n[1]}
N 1480 -3660 1480 -3650 {lab=col_n[1]}
N 1830 -3700 1830 -3660 {lab=col_n[2]}
N 1860 -3640 1860 -3400 {lab=col[2]}
N 1850 -3650 1860 -3640 {lab=col[2]}
N 1850 -3700 1850 -3650 {lab=col[2]}
N 1840 -3640 1840 -3400 {lab=col_n[2]}
N 1830 -3650 1840 -3640 {lab=col_n[2]}
N 1830 -3660 1830 -3650 {lab=col_n[2]}
N 2180 -3700 2180 -3660 {lab=col_n[3]}
N 2210 -3640 2210 -3400 {lab=col[3]}
N 2200 -3650 2210 -3640 {lab=col[3]}
N 2200 -3700 2200 -3650 {lab=col[3]}
N 2190 -3640 2190 -3400 {lab=col_n[3]}
N 2180 -3650 2190 -3640 {lab=col_n[3]}
N 2180 -3660 2180 -3650 {lab=col_n[3]}
N 2530 -3700 2530 -3660 {lab=col_n[4]}
N 2560 -3640 2560 -3400 {lab=col[4]}
N 2550 -3650 2560 -3640 {lab=col[4]}
N 2550 -3700 2550 -3650 {lab=col[4]}
N 2540 -3640 2540 -3400 {lab=col_n[4]}
N 2530 -3650 2540 -3640 {lab=col_n[4]}
N 2530 -3660 2530 -3650 {lab=col_n[4]}
N 2870 -3700 2870 -3660 {lab=col_n[5]}
N 2900 -3640 2900 -3400 {lab=col[5]}
N 2890 -3650 2900 -3640 {lab=col[5]}
N 2890 -3700 2890 -3650 {lab=col[5]}
N 2880 -3640 2880 -3400 {lab=col_n[5]}
N 2870 -3650 2880 -3640 {lab=col_n[5]}
N 2870 -3660 2870 -3650 {lab=col_n[5]}
N 3220 -3700 3220 -3660 {lab=col_n[6]}
N 3250 -3640 3250 -3400 {lab=col[6]}
N 3240 -3650 3250 -3640 {lab=col[6]}
N 3240 -3700 3240 -3650 {lab=col[6]}
N 3230 -3640 3230 -3400 {lab=col_n[6]}
N 3220 -3650 3230 -3640 {lab=col_n[6]}
N 3220 -3660 3220 -3650 {lab=col_n[6]}
N 3580 -3700 3580 -3660 {lab=col_n[7]}
N 3610 -3640 3610 -3400 {lab=col[7]}
N 3600 -3650 3610 -3640 {lab=col[7]}
N 3600 -3700 3600 -3650 {lab=col[7]}
N 3590 -3640 3590 -3400 {lab=col_n[7]}
N 3580 -3650 3590 -3640 {lab=col_n[7]}
N 3580 -3660 3580 -3650 {lab=col_n[7]}
N 3910 -3700 3910 -3660 {lab=col_n[8]}
N 3940 -3640 3940 -3400 {lab=col[8]}
N 3930 -3650 3940 -3640 {lab=col[8]}
N 3930 -3700 3930 -3650 {lab=col[8]}
N 3920 -3640 3920 -3400 {lab=col_n[8]}
N 3910 -3650 3920 -3640 {lab=col_n[8]}
N 3910 -3660 3910 -3650 {lab=col_n[8]}
N 4240 -3700 4240 -3660 {lab=col_n[9]}
N 4270 -3640 4270 -3400 {lab=col[9]}
N 4260 -3650 4270 -3640 {lab=col[9]}
N 4260 -3700 4260 -3650 {lab=col[9]}
N 4250 -3640 4250 -3400 {lab=col_n[9]}
N 4240 -3650 4250 -3640 {lab=col_n[9]}
N 4240 -3660 4240 -3650 {lab=col_n[9]}
N 4590 -3700 4590 -3660 {lab=col_n[10]}
N 4620 -3640 4620 -3400 {lab=col[10]}
N 4610 -3650 4620 -3640 {lab=col[10]}
N 4610 -3700 4610 -3650 {lab=col[10]}
N 4600 -3640 4600 -3400 {lab=col_n[10]}
N 4590 -3650 4600 -3640 {lab=col_n[10]}
N 4590 -3660 4590 -3650 {lab=col_n[10]}
N 4940 -3700 4940 -3660 {lab=col_n[11]}
N 4970 -3640 4970 -3400 {lab=col[11]}
N 4960 -3650 4970 -3640 {lab=col[11]}
N 4960 -3700 4960 -3650 {lab=col[11]}
N 4950 -3640 4950 -3400 {lab=col_n[11]}
N 4940 -3650 4950 -3640 {lab=col_n[11]}
N 4940 -3660 4940 -3650 {lab=col_n[11]}
N 5280 -3700 5280 -3660 {lab=col_n[12]}
N 5310 -3640 5310 -3400 {lab=col[12]}
N 5300 -3650 5310 -3640 {lab=col[12]}
N 5300 -3700 5300 -3650 {lab=col[12]}
N 5290 -3640 5290 -3400 {lab=col_n[12]}
N 5280 -3650 5290 -3640 {lab=col_n[12]}
N 5280 -3660 5280 -3650 {lab=col_n[12]}
N 5620 -3700 5620 -3660 {lab=VDD}
N 5650 -3640 5650 -3400 {lab=VSS}
N 5640 -3650 5650 -3640 {lab=VSS}
N 5640 -3700 5640 -3650 {lab=VSS}
N 5630 -3640 5630 -3400 {lab=VDD}
N 5620 -3650 5630 -3640 {lab=VDD}
N 5620 -3660 5620 -3650 {lab=VDD}
N 5640 -3390 5650 -3400 {lab=VSS}
N 5620 -3390 5630 -3400 {lab=VDD}
N 5300 -3390 5310 -3400 {lab=col[12]}
N 5280 -3390 5290 -3400 {lab=col_n[12]}
N 4960 -3390 4970 -3400 {lab=col[11]}
N 4940 -3390 4950 -3400 {lab=col_n[11]}
N 4610 -3390 4620 -3400 {lab=col[10]}
N 4590 -3390 4600 -3400 {lab=col_n[10]}
N 4260 -3390 4270 -3400 {lab=col[9]}
N 4240 -3390 4250 -3400 {lab=col_n[9]}
N 3930 -3390 3940 -3400 {lab=col[8]}
N 3910 -3390 3920 -3400 {lab=col_n[8]}
N 3600 -3390 3610 -3400 {lab=col[7]}
N 3580 -3390 3590 -3400 {lab=col_n[7]}
N 3240 -3390 3250 -3400 {lab=col[6]}
N 3220 -3390 3230 -3400 {lab=col_n[6]}
N 2890 -3390 2900 -3400 {lab=col[5]}
N 2870 -3390 2880 -3400 {lab=col_n[5]}
N 2550 -3390 2560 -3400 {lab=col[4]}
N 2530 -3390 2540 -3400 {lab=col_n[4]}
N 2200 -3390 2210 -3400 {lab=col[3]}
N 2180 -3390 2190 -3400 {lab=col_n[3]}
N 1850 -3390 1860 -3400 {lab=col[2]}
N 1830 -3390 1840 -3400 {lab=col_n[2]}
N 1500 -3390 1510 -3400 {lab=col[1]}
N 1480 -3390 1490 -3400 {lab=col_n[1]}
N 1170 -3390 1180 -3400 {lab=col[0]}
N 1150 -3390 1160 -3400 {lab=col_n[0]}
N 930 -880 1030 -880 {lab=#net21}
N 930 -860 1030 -860 {lab=#net22}
N 720 -950 940 -950 {lab=rowoff_n[0]}
N 940 -950 950 -940 {lab=rowoff_n[0]}
N 950 -940 1030 -940 {lab=rowoff_n[0]}
N 720 -930 940 -930 {lab=row_n[0]}
N 940 -930 950 -920 {lab=row_n[0]}
N 950 -920 1030 -920 {lab=row_n[0]}
N 720 -910 940 -910 {lab=rowon_n[0]}
N 940 -910 950 -900 {lab=rowon_n[0]}
N 950 -900 1030 -900 {lab=rowon_n[0]}
N 830 -780 840 -790 {lab=VDD}
N 840 -1030 840 -790 {lab=VDD}
N 850 -780 860 -790 {lab=VSS}
N 860 -1030 860 -790 {lab=VSS}
N 710 -940 720 -950 {lab=rowoff_n[0]}
N 710 -920 720 -930 {lab=row_n[0]}
N 710 -900 720 -910 {lab=rowon_n[0]}
N 1150 -1040 1160 -1030 {lab=col_n[0]}
N 1150 -1080 1150 -1040 {lab=col_n[0]}
N 1170 -1080 1170 -1040 {lab=col[0]}
N 1170 -1040 1180 -1030 {lab=col[0]}
N 1160 -1030 1160 -790 {lab=col_n[0]}
N 1180 -1030 1180 -790 {lab=col[0]}
N 1480 -1040 1490 -1030 {lab=col_n[1]}
N 1480 -1080 1480 -1040 {lab=col_n[1]}
N 1500 -1080 1500 -1040 {lab=col[1]}
N 1500 -1040 1510 -1030 {lab=col[1]}
N 1490 -1030 1490 -790 {lab=col_n[1]}
N 1510 -1030 1510 -790 {lab=col[1]}
N 1830 -1040 1840 -1030 {lab=col_n[2]}
N 1830 -1080 1830 -1040 {lab=col_n[2]}
N 1850 -1080 1850 -1040 {lab=col[2]}
N 1850 -1040 1860 -1030 {lab=col[2]}
N 1840 -1030 1840 -790 {lab=col_n[2]}
N 1860 -1030 1860 -790 {lab=col[2]}
N 2180 -1040 2190 -1030 {lab=col_n[3]}
N 2180 -1080 2180 -1040 {lab=col_n[3]}
N 2200 -1080 2200 -1040 {lab=col[3]}
N 2200 -1040 2210 -1030 {lab=col[3]}
N 2190 -1030 2190 -790 {lab=col_n[3]}
N 2210 -1030 2210 -790 {lab=col[3]}
N 2530 -1040 2540 -1030 {lab=col_n[4]}
N 2530 -1080 2530 -1040 {lab=col_n[4]}
N 2550 -1080 2550 -1040 {lab=col[4]}
N 2550 -1040 2560 -1030 {lab=col[4]}
N 2540 -1030 2540 -790 {lab=col_n[4]}
N 2560 -1030 2560 -790 {lab=col[4]}
N 2870 -1040 2880 -1030 {lab=col_n[5]}
N 2870 -1080 2870 -1040 {lab=col_n[5]}
N 2890 -1080 2890 -1040 {lab=col[5]}
N 2890 -1040 2900 -1030 {lab=col[5]}
N 2880 -1030 2880 -790 {lab=col_n[5]}
N 2900 -1030 2900 -790 {lab=col[5]}
N 3220 -1040 3230 -1030 {lab=col_n[6]}
N 3220 -1080 3220 -1040 {lab=col_n[6]}
N 3240 -1080 3240 -1040 {lab=col[6]}
N 3240 -1040 3250 -1030 {lab=col[6]}
N 3230 -1030 3230 -790 {lab=col_n[6]}
N 3250 -1030 3250 -790 {lab=col[6]}
N 3580 -1040 3590 -1030 {lab=col_n[7]}
N 3580 -1080 3580 -1040 {lab=col_n[7]}
N 3600 -1080 3600 -1040 {lab=col[7]}
N 3600 -1040 3610 -1030 {lab=col[7]}
N 3590 -1030 3590 -790 {lab=col_n[7]}
N 3610 -1030 3610 -790 {lab=col[7]}
N 3910 -1040 3920 -1030 {lab=col_n[8]}
N 3910 -1080 3910 -1040 {lab=col_n[8]}
N 3930 -1080 3930 -1040 {lab=col[8]}
N 3930 -1040 3940 -1030 {lab=col[8]}
N 3920 -1030 3920 -790 {lab=col_n[8]}
N 3940 -1030 3940 -790 {lab=col[8]}
N 4240 -1040 4250 -1030 {lab=col_n[9]}
N 4240 -1080 4240 -1040 {lab=col_n[9]}
N 4260 -1080 4260 -1040 {lab=col[9]}
N 4260 -1040 4270 -1030 {lab=col[9]}
N 4250 -1030 4250 -790 {lab=col_n[9]}
N 4270 -1030 4270 -790 {lab=col[9]}
N 4590 -1040 4600 -1030 {lab=col_n[10]}
N 4590 -1080 4590 -1040 {lab=col_n[10]}
N 4610 -1080 4610 -1040 {lab=col[10]}
N 4610 -1040 4620 -1030 {lab=col[10]}
N 4600 -1030 4600 -790 {lab=col_n[10]}
N 4620 -1030 4620 -790 {lab=col[10]}
N 4940 -1040 4950 -1030 {lab=col_n[11]}
N 4940 -1080 4940 -1040 {lab=col_n[11]}
N 4960 -1080 4960 -1040 {lab=col[11]}
N 4960 -1040 4970 -1030 {lab=col[11]}
N 4950 -1030 4950 -790 {lab=col_n[11]}
N 4970 -1030 4970 -790 {lab=col[11]}
N 5280 -1040 5290 -1030 {lab=col_n[12]}
N 5280 -1080 5280 -1040 {lab=col_n[12]}
N 5300 -1080 5300 -1040 {lab=col[12]}
N 5300 -1040 5310 -1030 {lab=col[12]}
N 5290 -1030 5290 -790 {lab=col_n[12]}
N 5310 -1030 5310 -790 {lab=col[12]}
N 5620 -1040 5630 -1030 {lab=VDD}
N 5620 -1080 5620 -1040 {lab=VDD}
N 5640 -1080 5640 -1040 {lab=VSS}
N 5640 -1040 5650 -1030 {lab=VSS}
N 5630 -1030 5630 -790 {lab=VDD}
N 5650 -1030 5650 -790 {lab=VSS}
N 1150 -780 1160 -790 {lab=col_n[0]}
N 1170 -780 1180 -790 {lab=col[0]}
N 1030 -940 1040 -950 {lab=rowoff_n[0]}
N 1040 -950 1240 -950 {lab=rowoff_n[0]}
N 1240 -950 1250 -940 {lab=rowoff_n[0]}
N 1250 -940 1360 -940 {lab=rowoff_n[0]}
N 1030 -920 1040 -930 {lab=row_n[0]}
N 1040 -930 1240 -930 {lab=row_n[0]}
N 1240 -930 1250 -920 {lab=row_n[0]}
N 1250 -920 1360 -920 {lab=row_n[0]}
N 1030 -900 1040 -910 {lab=rowon_n[0]}
N 1040 -910 1240 -910 {lab=rowon_n[0]}
N 1240 -910 1250 -900 {lab=rowon_n[0]}
N 1250 -900 1360 -900 {lab=rowon_n[0]}
N 1030 -880 1040 -890 {lab=#net21}
N 1040 -890 1240 -890 {lab=#net21}
N 1240 -890 1250 -880 {lab=#net21}
N 1250 -880 1360 -880 {lab=#net21}
N 1030 -860 1040 -870 {lab=#net22}
N 1040 -870 1240 -870 {lab=#net22}
N 1240 -870 1250 -860 {lab=#net22}
N 1250 -860 1360 -860 {lab=#net22}
N 1480 -780 1490 -790 {lab=col_n[1]}
N 1500 -780 1510 -790 {lab=col[1]}
N 1390 -950 1590 -950 {lab=rowoff_n[0]}
N 1590 -950 1600 -940 {lab=rowoff_n[0]}
N 1600 -940 1710 -940 {lab=rowoff_n[0]}
N 1390 -930 1590 -930 {lab=row_n[0]}
N 1590 -930 1600 -920 {lab=row_n[0]}
N 1600 -920 1710 -920 {lab=row_n[0]}
N 1390 -910 1590 -910 {lab=rowon_n[0]}
N 1590 -910 1600 -900 {lab=rowon_n[0]}
N 1600 -900 1710 -900 {lab=rowon_n[0]}
N 1390 -890 1590 -890 {lab=#net21}
N 1590 -890 1600 -880 {lab=#net21}
N 1600 -880 1710 -880 {lab=#net21}
N 1390 -870 1590 -870 {lab=#net22}
N 1590 -870 1600 -860 {lab=#net22}
N 1600 -860 1710 -860 {lab=#net22}
N 1360 -940 1370 -950 {lab=rowoff_n[0]}
N 1370 -950 1390 -950 {lab=rowoff_n[0]}
N 1360 -920 1370 -930 {lab=row_n[0]}
N 1370 -930 1390 -930 {lab=row_n[0]}
N 1360 -900 1370 -910 {lab=rowon_n[0]}
N 1370 -910 1390 -910 {lab=rowon_n[0]}
N 1360 -880 1370 -890 {lab=#net21}
N 1370 -890 1390 -890 {lab=#net21}
N 1360 -860 1370 -870 {lab=#net22}
N 1370 -870 1390 -870 {lab=#net22}
N 1830 -780 1840 -790 {lab=col_n[2]}
N 1850 -780 1860 -790 {lab=col[2]}
N 1740 -950 1940 -950 {lab=rowoff_n[0]}
N 1940 -950 1950 -940 {lab=rowoff_n[0]}
N 1950 -940 2060 -940 {lab=rowoff_n[0]}
N 1740 -930 1940 -930 {lab=row_n[0]}
N 1940 -930 1950 -920 {lab=row_n[0]}
N 1950 -920 2060 -920 {lab=row_n[0]}
N 1740 -910 1940 -910 {lab=rowon_n[0]}
N 1940 -910 1950 -900 {lab=rowon_n[0]}
N 1950 -900 2060 -900 {lab=rowon_n[0]}
N 1740 -890 1940 -890 {lab=#net21}
N 1940 -890 1950 -880 {lab=#net21}
N 1950 -880 2060 -880 {lab=#net21}
N 1740 -870 1940 -870 {lab=#net22}
N 1940 -870 1950 -860 {lab=#net22}
N 1950 -860 2060 -860 {lab=#net22}
N 1710 -940 1720 -950 {lab=rowoff_n[0]}
N 1720 -950 1740 -950 {lab=rowoff_n[0]}
N 1710 -920 1720 -930 {lab=row_n[0]}
N 1720 -930 1740 -930 {lab=row_n[0]}
N 1710 -900 1720 -910 {lab=rowon_n[0]}
N 1720 -910 1740 -910 {lab=rowon_n[0]}
N 1710 -880 1720 -890 {lab=#net21}
N 1720 -890 1740 -890 {lab=#net21}
N 1710 -860 1720 -870 {lab=#net22}
N 1720 -870 1740 -870 {lab=#net22}
N 2180 -780 2190 -790 {lab=col_n[3]}
N 2200 -780 2210 -790 {lab=col[3]}
N 2530 -780 2540 -790 {lab=col_n[4]}
N 2550 -780 2560 -790 {lab=col[4]}
N 2060 -940 2070 -950 {lab=rowoff_n[0]}
N 2070 -950 2090 -950 {lab=rowoff_n[0]}
N 2060 -920 2070 -930 {lab=row_n[0]}
N 2070 -930 2090 -930 {lab=row_n[0]}
N 2060 -900 2070 -910 {lab=rowon_n[0]}
N 2070 -910 2090 -910 {lab=rowon_n[0]}
N 2060 -880 2070 -890 {lab=#net21}
N 2070 -890 2090 -890 {lab=#net21}
N 2060 -860 2070 -870 {lab=#net22}
N 2070 -870 2090 -870 {lab=#net22}
N 2090 -950 2270 -950 {lab=rowoff_n[0]}
N 2270 -950 2280 -940 {lab=rowoff_n[0]}
N 2280 -940 2410 -940 {lab=rowoff_n[0]}
N 2090 -930 2270 -930 {lab=row_n[0]}
N 2270 -930 2280 -920 {lab=row_n[0]}
N 2280 -920 2410 -920 {lab=row_n[0]}
N 2090 -910 2270 -910 {lab=rowon_n[0]}
N 2270 -910 2280 -900 {lab=rowon_n[0]}
N 2280 -900 2410 -900 {lab=rowon_n[0]}
N 2090 -890 2270 -890 {lab=#net21}
N 2090 -870 2270 -870 {lab=#net22}
N 2270 -870 2280 -860 {lab=#net22}
N 2280 -860 2410 -860 {lab=#net22}
N 2280 -880 2410 -880 {lab=#net21}
N 2270 -890 2280 -880 {lab=#net21}
N 2870 -780 2880 -790 {lab=col_n[5]}
N 2890 -780 2900 -790 {lab=col[5]}
N 2410 -940 2420 -950 {lab=rowoff_n[0]}
N 2420 -950 2620 -950 {lab=rowoff_n[0]}
N 2410 -920 2420 -930 {lab=row_n[0]}
N 2420 -930 2620 -930 {lab=row_n[0]}
N 2620 -930 2630 -920 {lab=row_n[0]}
N 2630 -920 2750 -920 {lab=row_n[0]}
N 2620 -950 2630 -940 {lab=rowoff_n[0]}
N 2630 -940 2750 -940 {lab=rowoff_n[0]}
N 2410 -900 2420 -910 {lab=rowon_n[0]}
N 2420 -910 2620 -910 {lab=rowon_n[0]}
N 2620 -910 2630 -900 {lab=rowon_n[0]}
N 2630 -900 2750 -900 {lab=rowon_n[0]}
N 2410 -880 2420 -890 {lab=#net21}
N 2420 -890 2620 -890 {lab=#net21}
N 2620 -890 2630 -880 {lab=#net21}
N 2630 -880 2750 -880 {lab=#net21}
N 2410 -860 2420 -870 {lab=#net22}
N 2420 -870 2620 -870 {lab=#net22}
N 2620 -870 2630 -860 {lab=#net22}
N 2630 -860 2750 -860 {lab=#net22}
N 2750 -940 2760 -950 {lab=rowoff_n[0]}
N 2760 -950 2960 -950 {lab=rowoff_n[0]}
N 2750 -920 2760 -930 {lab=row_n[0]}
N 2760 -930 2960 -930 {lab=row_n[0]}
N 2960 -930 2970 -920 {lab=row_n[0]}
N 2970 -920 3100 -920 {lab=row_n[0]}
N 2970 -940 3100 -940 {lab=rowoff_n[0]}
N 2960 -950 2970 -940 {lab=rowoff_n[0]}
N 2750 -900 2760 -910 {lab=rowon_n[0]}
N 2760 -910 2960 -910 {lab=rowon_n[0]}
N 2960 -910 2970 -900 {lab=rowon_n[0]}
N 2970 -900 3100 -900 {lab=rowon_n[0]}
N 2750 -880 2760 -890 {lab=#net21}
N 2760 -890 2960 -890 {lab=#net21}
N 2960 -890 2970 -880 {lab=#net21}
N 2970 -880 3100 -880 {lab=#net21}
N 2750 -860 2760 -870 {lab=#net22}
N 2760 -870 2960 -870 {lab=#net22}
N 2960 -870 2970 -860 {lab=#net22}
N 2970 -860 3100 -860 {lab=#net22}
N 3220 -780 3230 -790 {lab=col_n[6]}
N 3240 -780 3250 -790 {lab=col[6]}
N 3100 -940 3110 -950 {lab=rowoff_n[0]}
N 3110 -950 3310 -950 {lab=rowoff_n[0]}
N 3310 -950 3320 -940 {lab=rowoff_n[0]}
N 3320 -940 3460 -940 {lab=rowoff_n[0]}
N 3100 -920 3110 -930 {lab=row_n[0]}
N 3110 -930 3310 -930 {lab=row_n[0]}
N 3320 -920 3460 -920 {lab=row_n[0]}
N 3310 -930 3320 -920 {lab=row_n[0]}
N 3320 -900 3460 -900 {lab=rowon_n[0]}
N 3310 -910 3320 -900 {lab=rowon_n[0]}
N 3110 -910 3310 -910 {lab=rowon_n[0]}
N 3100 -900 3110 -910 {lab=rowon_n[0]}
N 3100 -880 3110 -890 {lab=#net21}
N 3110 -890 3310 -890 {lab=#net21}
N 3310 -890 3320 -880 {lab=#net21}
N 3320 -880 3460 -880 {lab=#net21}
N 3100 -860 3110 -870 {lab=#net22}
N 3110 -870 3310 -870 {lab=#net22}
N 3310 -870 3320 -860 {lab=#net22}
N 3320 -860 3460 -860 {lab=#net22}
N 3580 -780 3590 -790 {lab=col_n[7]}
N 3600 -780 3610 -790 {lab=col[7]}
N 3460 -940 3470 -950 {lab=rowoff_n[0]}
N 3470 -950 3670 -950 {lab=rowoff_n[0]}
N 3670 -950 3680 -940 {lab=rowoff_n[0]}
N 3680 -940 3790 -940 {lab=rowoff_n[0]}
N 3460 -920 3470 -930 {lab=row_n[0]}
N 3470 -930 3670 -930 {lab=row_n[0]}
N 3670 -930 3680 -920 {lab=row_n[0]}
N 3680 -920 3790 -920 {lab=row_n[0]}
N 3460 -900 3470 -910 {lab=rowon_n[0]}
N 3470 -910 3670 -910 {lab=rowon_n[0]}
N 3670 -910 3680 -900 {lab=rowon_n[0]}
N 3680 -900 3790 -900 {lab=rowon_n[0]}
N 3460 -880 3470 -890 {lab=#net21}
N 3470 -890 3670 -890 {lab=#net21}
N 3670 -890 3680 -880 {lab=#net21}
N 3680 -880 3790 -880 {lab=#net21}
N 3460 -860 3470 -870 {lab=#net22}
N 3470 -870 3670 -870 {lab=#net22}
N 3670 -870 3680 -860 {lab=#net22}
N 3680 -860 3790 -860 {lab=#net22}
N 3910 -780 3920 -790 {lab=col_n[8]}
N 3930 -780 3940 -790 {lab=col[8]}
N 4240 -780 4250 -790 {lab=col_n[9]}
N 4260 -780 4270 -790 {lab=col[9]}
N 3790 -940 3800 -950 {lab=rowoff_n[0]}
N 3800 -950 4000 -950 {lab=rowoff_n[0]}
N 4000 -950 4010 -940 {lab=rowoff_n[0]}
N 4010 -940 4120 -940 {lab=rowoff_n[0]}
N 4010 -920 4120 -920 {lab=row_n[0]}
N 4000 -930 4010 -920 {lab=row_n[0]}
N 3800 -930 4000 -930 {lab=row_n[0]}
N 3790 -920 3800 -930 {lab=row_n[0]}
N 3790 -900 3800 -910 {lab=rowon_n[0]}
N 3800 -910 4000 -910 {lab=rowon_n[0]}
N 4000 -910 4010 -900 {lab=rowon_n[0]}
N 4010 -900 4120 -900 {lab=rowon_n[0]}
N 4010 -880 4120 -880 {lab=#net21}
N 4000 -890 4010 -880 {lab=#net21}
N 3800 -890 4000 -890 {lab=#net21}
N 3790 -880 3800 -890 {lab=#net21}
N 3790 -860 3800 -870 {lab=#net22}
N 3800 -870 4000 -870 {lab=#net22}
N 4000 -870 4010 -860 {lab=#net22}
N 4010 -860 4120 -860 {lab=#net22}
N 4120 -940 4130 -950 {lab=rowoff_n[0]}
N 4130 -950 4330 -950 {lab=rowoff_n[0]}
N 4330 -950 4340 -940 {lab=rowoff_n[0]}
N 4340 -940 4470 -940 {lab=rowoff_n[0]}
N 4340 -920 4470 -920 {lab=row_n[0]}
N 4330 -930 4340 -920 {lab=row_n[0]}
N 4130 -930 4330 -930 {lab=row_n[0]}
N 4120 -920 4130 -930 {lab=row_n[0]}
N 4120 -900 4130 -910 {lab=rowon_n[0]}
N 4130 -910 4330 -910 {lab=rowon_n[0]}
N 4330 -910 4340 -900 {lab=rowon_n[0]}
N 4340 -900 4470 -900 {lab=rowon_n[0]}
N 4340 -880 4470 -880 {lab=#net21}
N 4330 -890 4340 -880 {lab=#net21}
N 4130 -890 4330 -890 {lab=#net21}
N 4120 -880 4130 -890 {lab=#net21}
N 4120 -860 4130 -870 {lab=#net22}
N 4130 -870 4330 -870 {lab=#net22}
N 4330 -870 4340 -860 {lab=#net22}
N 4340 -860 4470 -860 {lab=#net22}
N 4470 -940 4480 -950 {lab=rowoff_n[0]}
N 4480 -950 4680 -950 {lab=rowoff_n[0]}
N 4680 -950 4690 -940 {lab=rowoff_n[0]}
N 4690 -940 4820 -940 {lab=rowoff_n[0]}
N 4470 -920 4480 -930 {lab=row_n[0]}
N 4480 -930 4680 -930 {lab=row_n[0]}
N 4680 -930 4690 -920 {lab=row_n[0]}
N 4690 -920 4820 -920 {lab=row_n[0]}
N 4470 -900 4480 -910 {lab=rowon_n[0]}
N 4480 -910 4680 -910 {lab=rowon_n[0]}
N 4680 -910 4690 -900 {lab=rowon_n[0]}
N 4690 -900 4820 -900 {lab=rowon_n[0]}
N 4470 -880 4480 -890 {lab=#net21}
N 4480 -890 4680 -890 {lab=#net21}
N 4680 -890 4690 -880 {lab=#net21}
N 4690 -880 4820 -880 {lab=#net21}
N 4470 -860 4480 -870 {lab=#net22}
N 4480 -870 4680 -870 {lab=#net22}
N 4680 -870 4690 -860 {lab=#net22}
N 4690 -860 4820 -860 {lab=#net22}
N 4590 -780 4600 -790 {lab=col_n[10]}
N 4610 -780 4620 -790 {lab=col[10]}
N 4940 -780 4950 -790 {lab=col_n[11]}
N 4960 -780 4970 -790 {lab=col[11]}
N 4820 -940 4830 -950 {lab=rowoff_n[0]}
N 4830 -950 5030 -950 {lab=rowoff_n[0]}
N 5030 -950 5040 -940 {lab=rowoff_n[0]}
N 5040 -940 5160 -940 {lab=rowoff_n[0]}
N 4820 -920 4830 -930 {lab=row_n[0]}
N 4830 -930 5030 -930 {lab=row_n[0]}
N 5030 -930 5040 -920 {lab=row_n[0]}
N 5040 -920 5160 -920 {lab=row_n[0]}
N 4820 -900 4830 -910 {lab=rowon_n[0]}
N 4830 -910 5030 -910 {lab=rowon_n[0]}
N 5030 -910 5040 -900 {lab=rowon_n[0]}
N 5040 -900 5160 -900 {lab=rowon_n[0]}
N 4820 -880 4830 -890 {lab=#net21}
N 4830 -890 5030 -890 {lab=#net21}
N 5030 -890 5040 -880 {lab=#net21}
N 5040 -880 5160 -880 {lab=#net21}
N 4820 -860 4830 -870 {lab=#net22}
N 4830 -870 5030 -870 {lab=#net22}
N 5030 -870 5040 -860 {lab=#net22}
N 5040 -860 5160 -860 {lab=#net22}
N 5160 -940 5170 -950 {lab=rowoff_n[0]}
N 5170 -950 5370 -950 {lab=rowoff_n[0]}
N 5370 -950 5380 -940 {lab=rowoff_n[0]}
N 5380 -940 5500 -940 {lab=rowoff_n[0]}
N 5160 -920 5170 -930 {lab=row_n[0]}
N 5170 -930 5370 -930 {lab=row_n[0]}
N 5370 -930 5380 -920 {lab=row_n[0]}
N 5380 -920 5500 -920 {lab=row_n[0]}
N 5160 -900 5170 -910 {lab=rowon_n[0]}
N 5170 -910 5370 -910 {lab=rowon_n[0]}
N 5370 -910 5380 -900 {lab=rowon_n[0]}
N 5380 -900 5500 -900 {lab=rowon_n[0]}
N 5160 -880 5170 -890 {lab=#net21}
N 5170 -890 5370 -890 {lab=#net21}
N 5370 -890 5380 -880 {lab=#net21}
N 5380 -880 5500 -880 {lab=#net21}
N 5160 -860 5170 -870 {lab=#net22}
N 5170 -870 5370 -870 {lab=#net22}
N 5370 -870 5380 -860 {lab=#net22}
N 5380 -860 5500 -860 {lab=#net22}
N 5280 -780 5290 -790 {lab=col_n[12]}
N 5300 -780 5310 -790 {lab=col[12]}
N 5620 -780 5630 -790 {lab=VDD}
N 5640 -780 5650 -790 {lab=VSS}
N 5500 -940 5510 -950 {lab=rowoff_n[0]}
N 5510 -950 5710 -950 {lab=rowoff_n[0]}
N 5710 -950 5720 -940 {lab=rowoff_n[0]}
N 5500 -920 5510 -930 {lab=row_n[0]}
N 5510 -930 5710 -930 {lab=row_n[0]}
N 5710 -930 5720 -920 {lab=row_n[0]}
N 5500 -900 5510 -910 {lab=rowon_n[0]}
N 5510 -910 5710 -910 {lab=rowon_n[0]}
N 5710 -910 5720 -900 {lab=rowon_n[0]}
N 5500 -880 5510 -890 {lab=#net21}
N 5510 -890 5710 -890 {lab=#net21}
N 5710 -890 5720 -880 {lab=#net21}
N 5500 -860 5510 -870 {lab=#net22}
N 5510 -870 5710 -870 {lab=#net22}
N 5710 -870 5720 -860 {lab=#net22}
N 830 -460 840 -470 {lab=VDD}
N 840 -730 840 -470 {lab=VDD}
N 830 -740 840 -730 {lab=VDD}
N 830 -780 830 -740 {lab=VDD}
N 850 -460 860 -470 {lab=VSS}
N 860 -730 860 -470 {lab=VSS}
N 850 -740 860 -730 {lab=VSS}
N 850 -780 850 -740 {lab=VSS}
N 1160 -730 1160 -470 {lab=col_n[0]}
N 1150 -740 1160 -730 {lab=col_n[0]}
N 1150 -780 1150 -740 {lab=col_n[0]}
N 1180 -730 1180 -470 {lab=col[0]}
N 1170 -740 1180 -730 {lab=col[0]}
N 1170 -780 1170 -740 {lab=col[0]}
N 1490 -730 1490 -470 {lab=col_n[1]}
N 1480 -740 1490 -730 {lab=col_n[1]}
N 1480 -780 1480 -740 {lab=col_n[1]}
N 1510 -730 1510 -470 {lab=col[1]}
N 1500 -740 1510 -730 {lab=col[1]}
N 1500 -780 1500 -740 {lab=col[1]}
N 1840 -730 1840 -470 {lab=col_n[2]}
N 1830 -740 1840 -730 {lab=col_n[2]}
N 1830 -780 1830 -740 {lab=col_n[2]}
N 1860 -730 1860 -470 {lab=col[2]}
N 1850 -740 1860 -730 {lab=col[2]}
N 1850 -780 1850 -740 {lab=col[2]}
N 2190 -730 2190 -470 {lab=col_n[3]}
N 2180 -740 2190 -730 {lab=col_n[3]}
N 2180 -780 2180 -740 {lab=col_n[3]}
N 2210 -730 2210 -470 {lab=col[3]}
N 2200 -740 2210 -730 {lab=col[3]}
N 2200 -780 2200 -740 {lab=col[3]}
N 2540 -730 2540 -470 {lab=col_n[4]}
N 2530 -740 2540 -730 {lab=col_n[4]}
N 2530 -780 2530 -740 {lab=col_n[4]}
N 2560 -730 2560 -470 {lab=col[4]}
N 2550 -740 2560 -730 {lab=col[4]}
N 2550 -780 2550 -740 {lab=col[4]}
N 2880 -730 2880 -470 {lab=col_n[5]}
N 2870 -740 2880 -730 {lab=col_n[5]}
N 2870 -780 2870 -740 {lab=col_n[5]}
N 2900 -730 2900 -470 {lab=col[5]}
N 2890 -740 2900 -730 {lab=col[5]}
N 2890 -780 2890 -740 {lab=col[5]}
N 3230 -730 3230 -470 {lab=col_n[6]}
N 3220 -740 3230 -730 {lab=col_n[6]}
N 3220 -780 3220 -740 {lab=col_n[6]}
N 3250 -730 3250 -470 {lab=col[6]}
N 3240 -740 3250 -730 {lab=col[6]}
N 3240 -780 3240 -740 {lab=col[6]}
N 3590 -730 3590 -470 {lab=col_n[7]}
N 3580 -740 3590 -730 {lab=col_n[7]}
N 3580 -780 3580 -740 {lab=col_n[7]}
N 3610 -730 3610 -470 {lab=col[7]}
N 3600 -740 3610 -730 {lab=col[7]}
N 3600 -780 3600 -740 {lab=col[7]}
N 3920 -730 3920 -470 {lab=col_n[8]}
N 3910 -740 3920 -730 {lab=col_n[8]}
N 3910 -780 3910 -740 {lab=col_n[8]}
N 3940 -730 3940 -470 {lab=col[8]}
N 3930 -740 3940 -730 {lab=col[8]}
N 3930 -780 3930 -740 {lab=col[8]}
N 4250 -730 4250 -470 {lab=col_n[9]}
N 4240 -740 4250 -730 {lab=col_n[9]}
N 4240 -780 4240 -740 {lab=col_n[9]}
N 4270 -730 4270 -470 {lab=col[9]}
N 4260 -740 4270 -730 {lab=col[9]}
N 4260 -780 4260 -740 {lab=col[9]}
N 4600 -730 4600 -470 {lab=col_n[10]}
N 4590 -740 4600 -730 {lab=col_n[10]}
N 4590 -780 4590 -740 {lab=col_n[10]}
N 4620 -730 4620 -470 {lab=col[10]}
N 4610 -740 4620 -730 {lab=col[10]}
N 4610 -780 4610 -740 {lab=col[10]}
N 4950 -730 4950 -470 {lab=col_n[11]}
N 4940 -740 4950 -730 {lab=col_n[11]}
N 4940 -780 4940 -740 {lab=col_n[11]}
N 4970 -730 4970 -470 {lab=col[11]}
N 4960 -740 4970 -730 {lab=col[11]}
N 4960 -780 4960 -740 {lab=col[11]}
N 5290 -730 5290 -470 {lab=col_n[12]}
N 5280 -740 5290 -730 {lab=col_n[12]}
N 5280 -780 5280 -740 {lab=col_n[12]}
N 5310 -730 5310 -470 {lab=col[12]}
N 5300 -740 5310 -730 {lab=col[12]}
N 5300 -780 5300 -740 {lab=col[12]}
N 5630 -730 5630 -470 {lab=VDD}
N 5620 -740 5630 -730 {lab=VDD}
N 5620 -780 5620 -740 {lab=VDD}
N 5650 -730 5650 -470 {lab=VSS}
N 5640 -740 5650 -730 {lab=VSS}
N 5640 -780 5640 -740 {lab=VSS}
N 5620 -460 5630 -470 {lab=VDD}
N 5640 -460 5650 -470 {lab=VSS}
N 930 -560 1030 -560 {lab=#net23}
N 930 -540 1030 -540 {lab=#net24}
N 1150 -460 1160 -470 {lab=col_n[0]}
N 1170 -460 1180 -470 {lab=col[0]}
N 710 -620 720 -630 {lab=VDD}
N 720 -630 920 -630 {lab=VDD}
N 920 -630 930 -620 {lab=VDD}
N 930 -620 1030 -620 {lab=VDD}
N 710 -600 720 -610 {lab=VDD}
N 720 -610 920 -610 {lab=VDD}
N 920 -610 930 -600 {lab=VDD}
N 930 -600 1030 -600 {lab=VDD}
N 710 -580 720 -590 {lab=VSS}
N 720 -590 920 -590 {lab=VSS}
N 920 -590 930 -580 {lab=VSS}
N 930 -580 1030 -580 {lab=VSS}
N 1480 -460 1490 -470 {lab=col_n[1]}
N 1500 -460 1510 -470 {lab=col[1]}
N 1030 -620 1040 -630 {lab=VDD}
N 1040 -630 1240 -630 {lab=VDD}
N 1240 -630 1250 -620 {lab=VDD}
N 1250 -620 1360 -620 {lab=VDD}
N 1030 -600 1040 -610 {lab=VDD}
N 1040 -610 1240 -610 {lab=VDD}
N 1240 -610 1250 -600 {lab=VDD}
N 1250 -600 1360 -600 {lab=VDD}
N 1030 -580 1040 -590 {lab=VSS}
N 1040 -590 1240 -590 {lab=VSS}
N 1240 -590 1250 -580 {lab=VSS}
N 1250 -580 1360 -580 {lab=VSS}
N 1030 -560 1040 -570 {lab=#net23}
N 1040 -570 1240 -570 {lab=#net23}
N 1240 -570 1250 -560 {lab=#net23}
N 1250 -560 1360 -560 {lab=#net23}
N 1030 -540 1040 -550 {lab=#net24}
N 1040 -550 1240 -550 {lab=#net24}
N 1240 -550 1250 -540 {lab=#net24}
N 1250 -540 1360 -540 {lab=#net24}
N 1830 -460 1840 -470 {lab=col_n[2]}
N 1850 -460 1860 -470 {lab=col[2]}
N 1360 -620 1370 -630 {lab=VDD}
N 1370 -630 1570 -630 {lab=VDD}
N 1570 -630 1580 -620 {lab=VDD}
N 1580 -620 1710 -620 {lab=VDD}
N 1360 -600 1370 -610 {lab=VDD}
N 1370 -610 1570 -610 {lab=VDD}
N 1570 -610 1580 -600 {lab=VDD}
N 1360 -580 1370 -590 {lab=VSS}
N 1370 -590 1570 -590 {lab=VSS}
N 1570 -590 1580 -580 {lab=VSS}
N 1580 -580 1710 -580 {lab=VSS}
N 1580 -600 1710 -600 {lab=VDD}
N 1360 -560 1370 -570 {lab=#net23}
N 1370 -570 1570 -570 {lab=#net23}
N 1570 -570 1580 -560 {lab=#net23}
N 1580 -560 1710 -560 {lab=#net23}
N 1360 -540 1370 -550 {lab=#net24}
N 1370 -550 1570 -550 {lab=#net24}
N 1570 -550 1580 -540 {lab=#net24}
N 1580 -540 1710 -540 {lab=#net24}
N 2180 -460 2190 -470 {lab=col_n[3]}
N 2200 -460 2210 -470 {lab=col[3]}
N 1710 -620 1720 -630 {lab=VDD}
N 1720 -630 1920 -630 {lab=VDD}
N 1920 -630 1930 -620 {lab=VDD}
N 1930 -620 2060 -620 {lab=VDD}
N 1710 -600 1720 -610 {lab=VDD}
N 1720 -610 1920 -610 {lab=VDD}
N 1920 -610 1930 -600 {lab=VDD}
N 1930 -600 2060 -600 {lab=VDD}
N 1710 -580 1720 -590 {lab=VSS}
N 1720 -590 1920 -590 {lab=VSS}
N 1920 -590 1930 -580 {lab=VSS}
N 1930 -580 2060 -580 {lab=VSS}
N 1710 -560 1720 -570 {lab=#net23}
N 1720 -570 1920 -570 {lab=#net23}
N 1920 -570 1930 -560 {lab=#net23}
N 1930 -560 2060 -560 {lab=#net23}
N 1710 -540 1720 -550 {lab=#net24}
N 1720 -550 1920 -550 {lab=#net24}
N 1920 -550 1930 -540 {lab=#net24}
N 1930 -540 2060 -540 {lab=#net24}
N 2530 -460 2540 -470 {lab=col_n[4]}
N 2550 -460 2560 -470 {lab=col[4]}
N 2060 -620 2070 -630 {lab=VDD}
N 2070 -630 2270 -630 {lab=VDD}
N 2270 -630 2280 -620 {lab=VDD}
N 2280 -620 2410 -620 {lab=VDD}
N 2060 -600 2070 -610 {lab=VDD}
N 2070 -610 2270 -610 {lab=VDD}
N 2270 -610 2280 -600 {lab=VDD}
N 2280 -600 2410 -600 {lab=VDD}
N 2060 -580 2070 -590 {lab=VSS}
N 2070 -590 2270 -590 {lab=VSS}
N 2270 -590 2280 -580 {lab=VSS}
N 2280 -580 2410 -580 {lab=VSS}
N 2060 -560 2070 -570 {lab=#net23}
N 2070 -570 2270 -570 {lab=#net23}
N 2270 -570 2280 -560 {lab=#net23}
N 2280 -560 2410 -560 {lab=#net23}
N 2060 -540 2070 -550 {lab=#net24}
N 2070 -550 2270 -550 {lab=#net24}
N 2270 -550 2280 -540 {lab=#net24}
N 2280 -540 2410 -540 {lab=#net24}
N 2410 -620 2420 -630 {lab=VDD}
N 2420 -630 2620 -630 {lab=VDD}
N 2620 -630 2630 -620 {lab=VDD}
N 2630 -620 2750 -620 {lab=VDD}
N 2410 -600 2420 -610 {lab=VDD}
N 2420 -610 2620 -610 {lab=VDD}
N 2620 -610 2630 -600 {lab=VDD}
N 2630 -600 2750 -600 {lab=VDD}
N 2410 -580 2420 -590 {lab=VSS}
N 2420 -590 2620 -590 {lab=VSS}
N 2620 -590 2630 -580 {lab=VSS}
N 2630 -580 2750 -580 {lab=VSS}
N 2410 -560 2420 -570 {lab=#net23}
N 2420 -570 2620 -570 {lab=#net23}
N 2620 -570 2630 -560 {lab=#net23}
N 2630 -560 2750 -560 {lab=#net23}
N 2410 -540 2420 -550 {lab=#net24}
N 2420 -550 2620 -550 {lab=#net24}
N 2620 -550 2630 -540 {lab=#net24}
N 2630 -540 2750 -540 {lab=#net24}
N 2870 -460 2880 -470 {lab=col_n[5]}
N 2890 -460 2900 -470 {lab=col[5]}
N 2750 -620 2760 -630 {lab=VDD}
N 2760 -630 2960 -630 {lab=VDD}
N 2960 -630 2970 -620 {lab=VDD}
N 2970 -620 3100 -620 {lab=VDD}
N 2760 -610 2960 -610 {lab=VDD}
N 2960 -610 2970 -600 {lab=VDD}
N 2970 -600 3100 -600 {lab=VDD}
N 2760 -590 2960 -590 {lab=VSS}
N 2960 -590 2970 -580 {lab=VSS}
N 2970 -580 3100 -580 {lab=VSS}
N 2760 -570 2960 -570 {lab=#net23}
N 2960 -570 2970 -560 {lab=#net23}
N 2970 -560 3100 -560 {lab=#net23}
N 2760 -550 2960 -550 {lab=#net24}
N 2960 -550 2970 -540 {lab=#net24}
N 2970 -540 3100 -540 {lab=#net24}
N 2750 -600 2760 -610 {lab=VDD}
N 2750 -580 2760 -590 {lab=VSS}
N 2750 -560 2760 -570 {lab=#net23}
N 2750 -540 2760 -550 {lab=#net24}
N 3100 -620 3110 -630 {lab=VDD}
N 3110 -630 3310 -630 {lab=VDD}
N 3310 -630 3320 -620 {lab=VDD}
N 3320 -620 3460 -620 {lab=VDD}
N 3100 -600 3110 -610 {lab=VDD}
N 3110 -610 3310 -610 {lab=VDD}
N 3310 -610 3320 -600 {lab=VDD}
N 3320 -600 3460 -600 {lab=VDD}
N 3100 -580 3110 -590 {lab=VSS}
N 3110 -590 3310 -590 {lab=VSS}
N 3310 -590 3320 -580 {lab=VSS}
N 3320 -580 3460 -580 {lab=VSS}
N 3100 -560 3110 -570 {lab=#net23}
N 3110 -570 3310 -570 {lab=#net23}
N 3310 -570 3320 -560 {lab=#net23}
N 3320 -560 3460 -560 {lab=#net23}
N 3100 -540 3110 -550 {lab=#net24}
N 3110 -550 3310 -550 {lab=#net24}
N 3310 -550 3320 -540 {lab=#net24}
N 3320 -540 3460 -540 {lab=#net24}
N 3220 -460 3230 -470 {lab=col_n[6]}
N 3240 -460 3250 -470 {lab=col[6]}
N 3580 -460 3590 -470 {lab=col_n[7]}
N 3600 -460 3610 -470 {lab=col[7]}
N 3460 -620 3470 -630 {lab=VDD}
N 3470 -630 3670 -630 {lab=VDD}
N 3670 -630 3680 -620 {lab=VDD}
N 3680 -620 3790 -620 {lab=VDD}
N 3460 -600 3470 -610 {lab=VDD}
N 3470 -610 3670 -610 {lab=VDD}
N 3670 -610 3680 -600 {lab=VDD}
N 3680 -600 3790 -600 {lab=VDD}
N 3460 -580 3470 -590 {lab=VSS}
N 3470 -590 3670 -590 {lab=VSS}
N 3670 -590 3680 -580 {lab=VSS}
N 3680 -580 3790 -580 {lab=VSS}
N 3460 -560 3470 -570 {lab=#net23}
N 3470 -570 3670 -570 {lab=#net23}
N 3670 -570 3680 -560 {lab=#net23}
N 3680 -560 3790 -560 {lab=#net23}
N 3460 -540 3470 -550 {lab=#net24}
N 3470 -550 3670 -550 {lab=#net24}
N 3670 -550 3680 -540 {lab=#net24}
N 3680 -540 3790 -540 {lab=#net24}
N 3790 -620 3800 -630 {lab=VDD}
N 3800 -630 4000 -630 {lab=VDD}
N 4000 -630 4010 -620 {lab=VDD}
N 4010 -620 4120 -620 {lab=VDD}
N 3910 -460 3920 -470 {lab=col_n[8]}
N 3930 -460 3940 -470 {lab=col[8]}
N 3790 -600 3800 -610 {lab=VDD}
N 3800 -610 4000 -610 {lab=VDD}
N 4000 -610 4010 -600 {lab=VDD}
N 4010 -600 4120 -600 {lab=VDD}
N 3790 -580 3800 -590 {lab=VSS}
N 3800 -590 4000 -590 {lab=VSS}
N 4000 -590 4010 -580 {lab=VSS}
N 4010 -580 4120 -580 {lab=VSS}
N 3790 -560 3800 -570 {lab=#net23}
N 3800 -570 4000 -570 {lab=#net23}
N 4000 -570 4010 -560 {lab=#net23}
N 4010 -560 4120 -560 {lab=#net23}
N 3790 -540 3800 -550 {lab=#net24}
N 3800 -550 4000 -550 {lab=#net24}
N 4000 -550 4010 -540 {lab=#net24}
N 4010 -540 4120 -540 {lab=#net24}
N 4240 -460 4250 -470 {lab=col_n[9]}
N 4260 -460 4270 -470 {lab=col[9]}
N 4120 -620 4130 -630 {lab=VDD}
N 4130 -630 4330 -630 {lab=VDD}
N 4330 -630 4340 -620 {lab=VDD}
N 4340 -620 4470 -620 {lab=VDD}
N 4120 -600 4130 -610 {lab=VDD}
N 4130 -610 4330 -610 {lab=VDD}
N 4330 -610 4340 -600 {lab=VDD}
N 4340 -600 4470 -600 {lab=VDD}
N 4120 -580 4130 -590 {lab=VSS}
N 4130 -590 4330 -590 {lab=VSS}
N 4330 -590 4340 -580 {lab=VSS}
N 4340 -580 4470 -580 {lab=VSS}
N 4130 -570 4330 -570 {lab=#net23}
N 4330 -570 4340 -560 {lab=#net23}
N 4340 -560 4470 -560 {lab=#net23}
N 4130 -550 4330 -550 {lab=#net24}
N 4330 -550 4340 -540 {lab=#net24}
N 4340 -540 4470 -540 {lab=#net24}
N 4120 -560 4130 -570 {lab=#net23}
N 4120 -540 4130 -550 {lab=#net24}
N 4480 -630 4680 -630 {lab=VDD}
N 4680 -630 4690 -620 {lab=VDD}
N 4690 -620 4820 -620 {lab=VDD}
N 4480 -610 4680 -610 {lab=VDD}
N 4680 -610 4690 -600 {lab=VDD}
N 4690 -600 4820 -600 {lab=VDD}
N 4480 -590 4680 -590 {lab=VSS}
N 4680 -590 4690 -580 {lab=VSS}
N 4690 -580 4820 -580 {lab=VSS}
N 4480 -570 4680 -570 {lab=#net23}
N 4680 -570 4690 -560 {lab=#net23}
N 4690 -560 4820 -560 {lab=#net23}
N 4480 -550 4680 -550 {lab=#net24}
N 4680 -550 4690 -540 {lab=#net24}
N 4690 -540 4820 -540 {lab=#net24}
N 4590 -460 4600 -470 {lab=col_n[10]}
N 4610 -460 4620 -470 {lab=col[10]}
N 4470 -620 4480 -630 {lab=VDD}
N 4470 -600 4480 -610 {lab=VDD}
N 4470 -580 4480 -590 {lab=VSS}
N 4470 -560 4480 -570 {lab=#net23}
N 4470 -540 4480 -550 {lab=#net24}
N 4960 -460 4970 -470 {lab=col[11]}
N 4940 -460 4950 -470 {lab=col_n[11]}
N 4820 -620 4830 -630 {lab=VDD}
N 4830 -630 5030 -630 {lab=VDD}
N 5030 -630 5040 -620 {lab=VDD}
N 5040 -620 5160 -620 {lab=VDD}
N 4830 -610 5030 -610 {lab=VDD}
N 5030 -610 5040 -600 {lab=VDD}
N 5040 -600 5160 -600 {lab=VDD}
N 4830 -590 5030 -590 {lab=VSS}
N 5030 -590 5040 -580 {lab=VSS}
N 5040 -580 5160 -580 {lab=VSS}
N 4830 -570 5030 -570 {lab=#net23}
N 5030 -570 5040 -560 {lab=#net23}
N 5040 -560 5160 -560 {lab=#net23}
N 4830 -550 5030 -550 {lab=#net24}
N 5030 -550 5040 -540 {lab=#net24}
N 5040 -540 5160 -540 {lab=#net24}
N 4820 -600 4830 -610 {lab=VDD}
N 4820 -580 4830 -590 {lab=VSS}
N 4820 -560 4830 -570 {lab=#net23}
N 4820 -540 4830 -550 {lab=#net24}
N 5160 -620 5170 -630 {lab=VDD}
N 5170 -630 5370 -630 {lab=VDD}
N 5370 -630 5380 -620 {lab=VDD}
N 5380 -620 5500 -620 {lab=VDD}
N 5170 -610 5370 -610 {lab=VDD}
N 5370 -610 5380 -600 {lab=VDD}
N 5380 -600 5500 -600 {lab=VDD}
N 5170 -590 5370 -590 {lab=VSS}
N 5370 -590 5380 -580 {lab=VSS}
N 5380 -580 5500 -580 {lab=VSS}
N 5170 -570 5370 -570 {lab=#net23}
N 5370 -570 5380 -560 {lab=#net23}
N 5380 -560 5500 -560 {lab=#net23}
N 5170 -550 5370 -550 {lab=#net24}
N 5370 -550 5380 -540 {lab=#net24}
N 5380 -540 5500 -540 {lab=#net24}
N 5280 -460 5290 -470 {lab=col_n[12]}
N 5300 -460 5310 -470 {lab=col[12]}
N 5160 -600 5170 -610 {lab=VDD}
N 5160 -580 5170 -590 {lab=VSS}
N 5160 -560 5170 -570 {lab=#net23}
N 5160 -540 5170 -550 {lab=#net24}
N 5500 -620 5510 -630 {lab=VDD}
N 5510 -630 5710 -630 {lab=VDD}
N 5710 -630 5720 -620 {lab=VDD}
N 5510 -610 5710 -610 {lab=VDD}
N 5710 -610 5720 -600 {lab=VDD}
N 5510 -590 5710 -590 {lab=VSS}
N 5710 -590 5720 -580 {lab=VSS}
N 5510 -570 5710 -570 {lab=#net23}
N 5710 -570 5720 -560 {lab=#net23}
N 5510 -550 5710 -550 {lab=#net24}
N 5710 -550 5720 -540 {lab=#net24}
N 5500 -600 5510 -610 {lab=VDD}
N 5500 -580 5510 -590 {lab=VSS}
N 5500 -560 5510 -570 {lab=#net23}
N 5500 -540 5510 -550 {lab=#net24}
N 5640 -4030 5650 -4040 {lab=VSS}
N 5650 -4240 5650 -4040 {lab=VSS}
N 5640 -4250 5650 -4240 {lab=VSS}
N 5640 -4270 5640 -4250 {lab=VSS}
N 5620 -4030 5630 -4040 {lab=VDD}
N 5630 -4240 5630 -4040 {lab=VDD}
N 5620 -4250 5630 -4240 {lab=VDD}
N 5620 -4270 5620 -4250 {lab=VDD}
N 5300 -4030 5310 -4040 {lab=col[12]}
N 5310 -4240 5310 -4040 {lab=col[12]}
N 5300 -4250 5310 -4240 {lab=col[12]}
N 5300 -4270 5300 -4250 {lab=col[12]}
N 5280 -4030 5290 -4040 {lab=col_n[12]}
N 5290 -4240 5290 -4040 {lab=col_n[12]}
N 5280 -4250 5290 -4240 {lab=col_n[12]}
N 5280 -4270 5280 -4250 {lab=col_n[12]}
N 4960 -4030 4970 -4040 {lab=col[11]}
N 4970 -4240 4970 -4040 {lab=col[11]}
N 4960 -4250 4970 -4240 {lab=col[11]}
N 4960 -4270 4960 -4250 {lab=col[11]}
N 4940 -4030 4950 -4040 {lab=col_n[11]}
N 4950 -4240 4950 -4040 {lab=col_n[11]}
N 4940 -4250 4950 -4240 {lab=col_n[11]}
N 4940 -4270 4940 -4250 {lab=col_n[11]}
N 4610 -4030 4620 -4040 {lab=col[10]}
N 4620 -4240 4620 -4040 {lab=col[10]}
N 4610 -4250 4620 -4240 {lab=col[10]}
N 4610 -4270 4610 -4250 {lab=col[10]}
N 4590 -4030 4600 -4040 {lab=col_n[10]}
N 4600 -4240 4600 -4040 {lab=col_n[10]}
N 4590 -4250 4600 -4240 {lab=col_n[10]}
N 4590 -4270 4590 -4250 {lab=col_n[10]}
N 4260 -4030 4270 -4040 {lab=col[9]}
N 4270 -4240 4270 -4040 {lab=col[9]}
N 4260 -4250 4270 -4240 {lab=col[9]}
N 4260 -4270 4260 -4250 {lab=col[9]}
N 4240 -4030 4250 -4040 {lab=col_n[9]}
N 4250 -4240 4250 -4040 {lab=col_n[9]}
N 4240 -4250 4250 -4240 {lab=col_n[9]}
N 4240 -4270 4240 -4250 {lab=col_n[9]}
N 3930 -4030 3940 -4040 {lab=col[8]}
N 3940 -4240 3940 -4040 {lab=col[8]}
N 3930 -4250 3940 -4240 {lab=col[8]}
N 3930 -4270 3930 -4250 {lab=col[8]}
N 3910 -4030 3920 -4040 {lab=col_n[8]}
N 3920 -4240 3920 -4040 {lab=col_n[8]}
N 3910 -4250 3920 -4240 {lab=col_n[8]}
N 3910 -4270 3910 -4250 {lab=col_n[8]}
N 3600 -4030 3610 -4040 {lab=col[7]}
N 3610 -4240 3610 -4040 {lab=col[7]}
N 3600 -4250 3610 -4240 {lab=col[7]}
N 3600 -4270 3600 -4250 {lab=col[7]}
N 3580 -4030 3590 -4040 {lab=col_n[7]}
N 3590 -4240 3590 -4040 {lab=col_n[7]}
N 3580 -4250 3590 -4240 {lab=col_n[7]}
N 3580 -4270 3580 -4250 {lab=col_n[7]}
N 3240 -4030 3250 -4040 {lab=col[6]}
N 3250 -4240 3250 -4040 {lab=col[6]}
N 3240 -4250 3250 -4240 {lab=col[6]}
N 3240 -4270 3240 -4250 {lab=col[6]}
N 3220 -4030 3230 -4040 {lab=col_n[6]}
N 3230 -4240 3230 -4040 {lab=col_n[6]}
N 3220 -4250 3230 -4240 {lab=col_n[6]}
N 3220 -4270 3220 -4250 {lab=col_n[6]}
N 2890 -4030 2900 -4040 {lab=col[5]}
N 2900 -4240 2900 -4040 {lab=col[5]}
N 2890 -4250 2900 -4240 {lab=col[5]}
N 2890 -4270 2890 -4250 {lab=col[5]}
N 2870 -4030 2880 -4040 {lab=col_n[5]}
N 2880 -4240 2880 -4040 {lab=col_n[5]}
N 2870 -4250 2880 -4240 {lab=col_n[5]}
N 2870 -4270 2870 -4250 {lab=col_n[5]}
N 2550 -4030 2560 -4040 {lab=col[4]}
N 2560 -4240 2560 -4040 {lab=col[4]}
N 2550 -4250 2560 -4240 {lab=col[4]}
N 2550 -4270 2550 -4250 {lab=col[4]}
N 2530 -4030 2540 -4040 {lab=col_n[4]}
N 2540 -4240 2540 -4040 {lab=col_n[4]}
N 2530 -4250 2540 -4240 {lab=col_n[4]}
N 2530 -4270 2530 -4250 {lab=col_n[4]}
N 2200 -4030 2210 -4040 {lab=col[3]}
N 2210 -4240 2210 -4040 {lab=col[3]}
N 2200 -4250 2210 -4240 {lab=col[3]}
N 2200 -4270 2200 -4250 {lab=col[3]}
N 2180 -4030 2190 -4040 {lab=col_n[3]}
N 2190 -4240 2190 -4040 {lab=col_n[3]}
N 2180 -4250 2190 -4240 {lab=col_n[3]}
N 2180 -4270 2180 -4250 {lab=col_n[3]}
N 1850 -4030 1860 -4040 {lab=col[2]}
N 1860 -4240 1860 -4040 {lab=col[2]}
N 1850 -4250 1860 -4240 {lab=col[2]}
N 1850 -4270 1850 -4250 {lab=col[2]}
N 1830 -4030 1840 -4040 {lab=col_n[2]}
N 1840 -4240 1840 -4040 {lab=col_n[2]}
N 1830 -4250 1840 -4240 {lab=col_n[2]}
N 1830 -4270 1830 -4250 {lab=col_n[2]}
N 1500 -4030 1510 -4040 {lab=col[1]}
N 1510 -4240 1510 -4040 {lab=col[1]}
N 1500 -4250 1510 -4240 {lab=col[1]}
N 1500 -4270 1500 -4250 {lab=col[1]}
N 1480 -4030 1490 -4040 {lab=col_n[1]}
N 1490 -4240 1490 -4040 {lab=col_n[1]}
N 1480 -4250 1490 -4240 {lab=col_n[1]}
N 1480 -4270 1480 -4250 {lab=col_n[1]}
N 1170 -4030 1180 -4040 {lab=col[0]}
N 1180 -4240 1180 -4040 {lab=col[0]}
N 1170 -4250 1180 -4240 {lab=col[0]}
N 1170 -4270 1170 -4250 {lab=col[0]}
N 1150 -4030 1160 -4040 {lab=col_n[0]}
N 1160 -4240 1160 -4040 {lab=col_n[0]}
N 1150 -4250 1160 -4240 {lab=col_n[0]}
N 1150 -4270 1150 -4250 {lab=col_n[0]}
N 850 -4030 860 -4040 {lab=VSS}
N 860 -4240 860 -4040 {lab=VSS}
N 850 -4250 860 -4240 {lab=VSS}
N 850 -4270 850 -4250 {lab=VSS}
N 830 -4030 840 -4040 {lab=VDD}
N 840 -4240 840 -4040 {lab=VDD}
N 830 -4250 840 -4240 {lab=VDD}
N 830 -4270 830 -4250 {lab=VDD}
C {adc_sar_wafflecap_drv.sym} 470 -410 0 0 {name=x2}
C {adc_sar_wafflecap_dummy.sym} 830 -370 0 0 {name=x1}
C {adc_sar_wafflecap_8_1.sym} 930 -350 0 0 {name=x3}
C {adc_sar_wafflecap_dummy.sym} 1510 -370 0 0 {name=x4}
C {adc_sar_wafflecap_dummy.sym} 1860 -370 0 0 {name=x5}
C {adc_sar_wafflecap_dummy.sym} 2210 -370 0 0 {name=x6}
C {adc_sar_wafflecap_dummy.sym} 2550 -370 0 0 {name=x7}
C {adc_sar_wafflecap_dummy.sym} 3920 -370 0 0 {name=x11}
C {adc_sar_wafflecap_dummy.sym} 4270 -370 0 0 {name=x12}
C {adc_sar_wafflecap_dummy.sym} 4620 -370 0 0 {name=x13}
C {adc_sar_wafflecap_8_2.sym} 3040 -290 0 0 {name=x8}
C {adc_sar_wafflecap_8_4.sym} 3120 -380 0 0 {name=x9}
C {adc_sar_wafflecap_8_1.sym} 3360 -350 0 0 {name=x10}
C {adc_sar_wafflecap_drv.sym} 470 -730 0 0 {name=x17}
C {adc_sar_wafflecap_dummy.sym} 830 -690 0 0 {name=x18}
C {adc_sar_wafflecap_dummy.sym} 1160 -690 0 0 {name=x19}
C {adc_sar_wafflecap_dummy.sym} 1510 -690 0 0 {name=x20}
C {adc_sar_wafflecap_8_8.sym} 1920 -610 0 0 {name=x21}
C {adc_sar_wafflecap_8_8.sym} 2270 -610 0 0 {name=x22}
C {adc_sar_wafflecap_8_8.sym} 2610 -610 0 0 {name=x23}
C {adc_sar_wafflecap_8_8.sym} 2960 -610 0 0 {name=x24}
C {adc_sar_wafflecap_8_8.sym} 3320 -610 0 0 {name=x25}
C {adc_sar_wafflecap_8_8.sym} 3650 -610 0 0 {name=x26}
C {adc_sar_wafflecap_8_8.sym} 3980 -610 0 0 {name=x27}
C {adc_sar_wafflecap_dummy.sym} 4270 -690 0 0 {name=x28}
C {adc_sar_wafflecap_dummy.sym} 4620 -690 0 0 {name=x29}
C {adc_sar_wafflecap_dummy.sym} 4960 -690 0 0 {name=x30}
C {adc_sar_wafflecap_dummy.sym} 5300 -690 0 0 {name=x31}
C {adc_sar_wafflecap_drv.sym} 470 -1030 0 0 {name=x33}
C {adc_sar_wafflecap_8_8.sym} 890 -910 0 0 {name=x34}
C {adc_sar_wafflecap_8_8.sym} 1220 -910 0 0 {name=x35}
C {adc_sar_wafflecap_8_8.sym} 1570 -910 0 0 {name=x36}
C {adc_sar_wafflecap_8_8.sym} 1920 -910 0 0 {name=x37}
C {adc_sar_wafflecap_8_8.sym} 2270 -910 0 0 {name=x38}
C {adc_sar_wafflecap_8_8.sym} 2610 -910 0 0 {name=x39}
C {adc_sar_wafflecap_8_8.sym} 2960 -910 0 0 {name=x40}
C {adc_sar_wafflecap_8_8.sym} 3320 -910 0 0 {name=x41}
C {adc_sar_wafflecap_8_8.sym} 3650 -910 0 0 {name=x42}
C {adc_sar_wafflecap_8_8.sym} 3980 -910 0 0 {name=x43}
C {adc_sar_wafflecap_8_8.sym} 4330 -910 0 0 {name=x44}
C {adc_sar_wafflecap_8_8.sym} 4680 -910 0 0 {name=x45}
C {adc_sar_wafflecap_8_8.sym} 5020 -910 0 0 {name=x46}
C {devices/lab_wire.sym} 690 -580 0 0 {name=l2050 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 690 -600 0 0 {name=l2051 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 690 -620 0 0 {name=l2058 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 690 -560 0 0 {name=l2111 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 690 -540 0 0 {name=l2112 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 750 -450 3 0 {name=l4354 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 830 -450 3 0 {name=l4358 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 850 -450 3 0 {name=l2057 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1070 -450 0 0 {name=l4359 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1150 -440 3 0 {name=l4363 sig_type=std_logic lab=col_n[0]}
C {devices/lab_wire.sym} 1170 -440 3 0 {name=l2060 sig_type=std_logic lab=col[0]}
C {devices/lab_wire.sym} 1400 -450 0 0 {name=l4364 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1480 -440 3 0 {name=l4367 sig_type=std_logic lab=col_n[1]}
C {devices/lab_wire.sym} 1430 -440 3 0 {name=l1 sig_type=std_logic lab=en_C0_n}
C {devices/lab_wire.sym} 1500 -440 3 0 {name=l2061 sig_type=std_logic lab=col[1]}
C {devices/lab_wire.sym} 750 -770 3 0 {name=l2 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 750 -1070 3 0 {name=l3 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1070 -1070 3 0 {name=l4 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1070 -770 3 0 {name=l5 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1400 -770 3 0 {name=l6 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1400 -1070 3 0 {name=l7 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1750 -1070 3 0 {name=l8 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1750 -770 3 0 {name=l9 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2100 -770 3 0 {name=l10 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2100 -1070 3 0 {name=l11 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2450 -1070 3 0 {name=l12 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2790 -1070 3 0 {name=l13 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2790 -770 3 0 {name=l14 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2450 -770 3 0 {name=l15 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3140 -1070 3 0 {name=l16 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3140 -770 3 0 {name=l17 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3500 -1070 3 0 {name=l18 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3830 -1070 3 0 {name=l19 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3500 -770 3 0 {name=l20 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3830 -770 3 0 {name=l21 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4160 -770 3 0 {name=l22 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4160 -1070 3 0 {name=l23 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4510 -1070 3 0 {name=l24 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4860 -1070 3 0 {name=l25 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4510 -770 3 0 {name=l26 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4860 -770 3 0 {name=l27 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5200 -1070 3 0 {name=l28 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5200 -770 3 0 {name=l29 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -1070 3 0 {name=l30 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -770 3 0 {name=l31 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2100 -450 0 0 {name=l4374 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2180 -440 3 0 {name=l4377 sig_type=std_logic lab=col_n[3]}
C {devices/lab_wire.sym} 2200 -440 3 0 {name=l2063 sig_type=std_logic lab=col[3]}
C {devices/lab_wire.sym} 1750 -450 0 0 {name=l4368 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1830 -440 3 0 {name=l4371 sig_type=std_logic lab=col_n[2]}
C {devices/lab_wire.sym} 1850 -440 3 0 {name=l2062 sig_type=std_logic lab=col[2]}
C {devices/lab_wire.sym} 2450 -450 0 0 {name=l4378 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2530 -440 3 0 {name=l4381 sig_type=std_logic lab=col_n[4]}
C {devices/lab_wire.sym} 2550 -440 3 0 {name=l2064 sig_type=std_logic lab=col[4]}
C {devices/lab_wire.sym} 2790 -450 0 0 {name=l4384 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2870 -440 3 0 {name=l4387 sig_type=std_logic lab=col_n[5]}
C {devices/lab_wire.sym} 2890 -440 3 0 {name=l2065 sig_type=std_logic lab=col[5]}
C {devices/lab_wire.sym} 3140 -450 0 0 {name=l4434 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3220 -440 3 0 {name=l4437 sig_type=std_logic lab=col_n[6]}
C {devices/lab_wire.sym} 3170 -440 3 0 {name=l4797 sig_type=std_logic lab=en_bit_n[1]}
C {devices/lab_wire.sym} 3240 -440 3 0 {name=l2075 sig_type=std_logic lab=col[6]}
C {devices/lab_wire.sym} 3500 -450 0 0 {name=l50 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3580 -440 3 0 {name=l51 sig_type=std_logic lab=col_n[7]}
C {devices/lab_wire.sym} 3530 -440 3 0 {name=l52 sig_type=std_logic lab=en_bit_n[2]}
C {devices/lab_wire.sym} 3600 -440 3 0 {name=l53 sig_type=std_logic lab=col[7]}
C {devices/lab_wire.sym} 3830 -450 0 0 {name=l54 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3910 -440 3 0 {name=l55 sig_type=std_logic lab=col_n[8]}
C {devices/lab_wire.sym} 3860 -440 3 0 {name=l56 sig_type=std_logic lab=en_bit_n[0]}
C {devices/lab_wire.sym} 3930 -440 3 0 {name=l57 sig_type=std_logic lab=col[8]}
C {devices/lab_wire.sym} 4240 -440 3 0 {name=l58 sig_type=std_logic lab=col_n[9]}
C {devices/lab_wire.sym} 4260 -440 3 0 {name=l59 sig_type=std_logic lab=col[9]}
C {devices/lab_wire.sym} 4160 -450 0 0 {name=l60 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4590 -440 3 0 {name=l61 sig_type=std_logic lab=col_n[10]}
C {devices/lab_wire.sym} 4610 -440 3 0 {name=l62 sig_type=std_logic lab=col[10]}
C {devices/lab_wire.sym} 4510 -450 0 0 {name=l63 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4940 -440 3 0 {name=l64 sig_type=std_logic lab=col_n[11]}
C {devices/lab_wire.sym} 4960 -440 3 0 {name=l65 sig_type=std_logic lab=col[11]}
C {devices/lab_wire.sym} 4860 -450 0 0 {name=l66 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5280 -440 3 0 {name=l67 sig_type=std_logic lab=col_n[12]}
C {devices/lab_wire.sym} 5300 -440 3 0 {name=l68 sig_type=std_logic lab=col[12]}
C {devices/lab_wire.sym} 5200 -450 0 0 {name=l69 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -450 0 0 {name=l4514 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5260 -440 3 0 {name=l2052 sig_type=std_logic lab=sw}
C {devices/lab_wire.sym} 5320 -440 3 0 {name=l2053 sig_type=std_logic lab=analog_in}
C {devices/lab_wire.sym} 5340 -440 3 0 {name=l2054 sig_type=std_logic lab=sw_n}
C {devices/lab_wire.sym} 5620 -440 3 0 {name=l4522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5640 -440 3 0 {name=l2092 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 750 -690 2 1 {name=l4509 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 770 -700 1 1 {name=l70 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 810 -700 3 0 {name=l71 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1070 -690 2 1 {name=l72 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1090 -700 1 1 {name=l73 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1130 -700 3 0 {name=l74 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -690 2 1 {name=l75 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -700 1 1 {name=l76 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -700 3 0 {name=l77 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1750 -690 2 1 {name=l78 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 -700 1 1 {name=l79 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1810 -700 3 0 {name=l80 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2100 -690 2 1 {name=l81 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2120 -700 1 1 {name=l82 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2160 -700 3 0 {name=l83 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2450 -690 2 1 {name=l84 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2470 -700 1 1 {name=l85 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2510 -700 3 0 {name=l86 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2790 -690 2 1 {name=l87 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2810 -700 1 1 {name=l88 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2850 -700 3 0 {name=l89 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3140 -690 2 1 {name=l90 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3160 -700 1 1 {name=l91 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3200 -700 3 0 {name=l92 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3500 -690 2 1 {name=l93 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3520 -700 1 1 {name=l94 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3560 -700 3 0 {name=l95 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3830 -690 2 1 {name=l96 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3850 -700 1 1 {name=l97 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3890 -700 3 0 {name=l98 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4160 -690 2 1 {name=l99 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -700 1 1 {name=l100 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4220 -700 3 0 {name=l101 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4510 -690 2 1 {name=l102 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4530 -700 1 1 {name=l103 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4570 -700 3 0 {name=l104 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4860 -690 2 1 {name=l105 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4880 -700 1 1 {name=l106 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4920 -700 3 0 {name=l107 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5200 -690 2 1 {name=l108 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5220 -700 1 1 {name=l109 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5260 -700 3 0 {name=l110 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -690 2 1 {name=l111 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -700 1 1 {name=l112 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5600 -700 3 0 {name=l113 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -1010 2 1 {name=l120 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -1020 1 1 {name=l121 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5600 -1020 3 0 {name=l122 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5540 -1310 2 1 {name=l123 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -1320 1 1 {name=l124 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5600 -1320 3 0 {name=l125 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4860 -1310 2 1 {name=l141 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4880 -1320 1 1 {name=l142 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4920 -1320 3 0 {name=l143 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5200 -1310 2 1 {name=l144 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5220 -1320 1 1 {name=l145 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5260 -1320 3 0 {name=l146 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5200 -1010 2 1 {name=l147 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5220 -1020 1 1 {name=l148 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5260 -1020 3 0 {name=l149 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4860 -1010 2 1 {name=l150 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4880 -1020 1 1 {name=l151 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4920 -1020 3 0 {name=l152 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4510 -1010 2 1 {name=l153 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4530 -1020 1 1 {name=l154 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4570 -1020 3 0 {name=l155 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4510 -1310 2 1 {name=l156 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4530 -1320 1 1 {name=l157 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4570 -1320 3 0 {name=l158 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4160 -1310 2 1 {name=l165 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -1320 1 1 {name=l166 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4220 -1320 3 0 {name=l167 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4160 -1010 2 1 {name=l168 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -1020 1 1 {name=l169 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4220 -1020 3 0 {name=l170 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3830 -1010 2 1 {name=l171 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3850 -1020 1 1 {name=l172 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3890 -1020 3 0 {name=l173 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3830 -1310 2 1 {name=l174 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3850 -1320 1 1 {name=l175 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3890 -1320 3 0 {name=l176 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3500 -1310 2 1 {name=l177 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3520 -1320 1 1 {name=l178 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3560 -1320 3 0 {name=l179 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3500 -1010 2 1 {name=l180 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3520 -1020 1 1 {name=l181 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3560 -1020 3 0 {name=l182 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3140 -1010 2 1 {name=l183 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3160 -1020 1 1 {name=l184 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3200 -1020 3 0 {name=l185 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3140 -1310 2 1 {name=l186 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3160 -1320 1 1 {name=l187 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3200 -1320 3 0 {name=l188 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2790 -1310 2 1 {name=l189 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2810 -1320 1 1 {name=l190 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2850 -1320 3 0 {name=l191 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2790 -1010 2 1 {name=l192 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2810 -1020 1 1 {name=l193 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2850 -1020 3 0 {name=l194 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2450 -1010 2 1 {name=l195 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2470 -1020 1 1 {name=l196 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2510 -1020 3 0 {name=l197 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2450 -1310 2 1 {name=l198 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2470 -1320 1 1 {name=l199 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2510 -1320 3 0 {name=l200 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2100 -1310 2 1 {name=l201 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2120 -1320 1 1 {name=l202 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2160 -1320 3 0 {name=l203 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2100 -1010 2 1 {name=l204 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2120 -1020 1 1 {name=l205 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2160 -1020 3 0 {name=l206 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1750 -1010 2 1 {name=l207 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 -1020 1 1 {name=l208 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1810 -1020 3 0 {name=l209 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1750 -1310 2 1 {name=l210 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 -1320 1 1 {name=l211 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1810 -1320 3 0 {name=l212 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -1310 2 1 {name=l213 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -1320 1 1 {name=l214 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -1320 3 0 {name=l215 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1070 -1310 2 1 {name=l216 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1090 -1320 1 1 {name=l217 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1130 -1320 3 0 {name=l218 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1070 -1010 2 1 {name=l219 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1090 -1020 1 1 {name=l220 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1130 -1020 3 0 {name=l221 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -1010 2 1 {name=l222 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -1020 1 1 {name=l223 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -1020 3 0 {name=l224 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 750 -1310 2 1 {name=l225 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 770 -1320 1 1 {name=l226 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 810 -1320 3 0 {name=l227 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 750 -1010 2 1 {name=l228 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 770 -1020 1 1 {name=l229 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 810 -1020 3 0 {name=l230 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 690 -860 0 0 {name=l4102 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 690 -920 0 0 {name=l4105 sig_type=std_logic lab=row_n[0]}
C {devices/lab_wire.sym} 690 -900 0 0 {name=l4104 sig_type=std_logic lab=rowon_n[0]}
C {devices/lab_wire.sym} 690 -880 0 0 {name=l4103 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 690 -940 0 0 {name=l2093 sig_type=std_logic lab=rowoff_n[0]}
C {devices/lab_wire.sym} 690 -1160 0 0 {name=l4110 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 690 -1220 0 0 {name=l4111 sig_type=std_logic lab=row_n[1]}
C {devices/lab_wire.sym} 690 -1200 0 0 {name=l4112 sig_type=std_logic lab=rowon_n[1]}
C {devices/lab_wire.sym} 690 -1180 0 0 {name=l4113 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 690 -1490 0 0 {name=l4118 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 690 -1550 0 0 {name=l4119 sig_type=std_logic lab=row_n[2]}
C {devices/lab_wire.sym} 690 -1530 0 0 {name=l4120 sig_type=std_logic lab=rowon_n[2]}
C {devices/lab_wire.sym} 690 -1510 0 0 {name=l4121 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 690 -1240 0 0 {name=l2094 sig_type=std_logic lab=rowoff_n[1]}
C {devices/lab_wire.sym} 690 -1570 0 0 {name=l2095 sig_type=std_logic lab=rowoff_n[2]}
C {adc_sar_wafflecap_drv.sym} 470 -1360 0 0 {name=x49}
C {adc_sar_wafflecap_8_8.sym} 890 -1240 0 0 {name=x50}
C {adc_sar_wafflecap_8_8.sym} 1220 -1240 0 0 {name=x51}
C {adc_sar_wafflecap_8_8.sym} 1570 -1240 0 0 {name=x52}
C {adc_sar_wafflecap_8_8.sym} 1920 -1240 0 0 {name=x53}
C {adc_sar_wafflecap_8_8.sym} 2270 -1240 0 0 {name=x54}
C {adc_sar_wafflecap_8_8.sym} 2610 -1240 0 0 {name=x55}
C {adc_sar_wafflecap_8_8.sym} 2960 -1240 0 0 {name=x56}
C {adc_sar_wafflecap_8_8.sym} 3320 -1240 0 0 {name=x57}
C {adc_sar_wafflecap_8_8.sym} 3650 -1240 0 0 {name=x58}
C {adc_sar_wafflecap_8_8.sym} 3980 -1240 0 0 {name=x59}
C {adc_sar_wafflecap_8_8.sym} 4330 -1240 0 0 {name=x60}
C {adc_sar_wafflecap_8_8.sym} 4680 -1240 0 0 {name=x61}
C {adc_sar_wafflecap_8_8.sym} 5020 -1240 0 0 {name=x62}
C {devices/lab_wire.sym} 750 -1400 3 0 {name=l34 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1070 -1400 3 0 {name=l35 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1400 -1400 3 0 {name=l36 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1750 -1400 3 0 {name=l37 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2100 -1400 3 0 {name=l38 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2450 -1400 3 0 {name=l39 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2790 -1400 3 0 {name=l40 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3140 -1400 3 0 {name=l41 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3500 -1400 3 0 {name=l42 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3830 -1400 3 0 {name=l43 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4160 -1400 3 0 {name=l44 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4510 -1400 3 0 {name=l45 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4860 -1400 3 0 {name=l46 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5200 -1400 3 0 {name=l47 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -1400 3 0 {name=l48 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -1640 2 1 {name=l129 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -1650 1 1 {name=l130 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5600 -1650 3 0 {name=l131 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4860 -1640 2 1 {name=l135 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4880 -1650 1 1 {name=l136 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4920 -1650 3 0 {name=l137 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5200 -1640 2 1 {name=l138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5220 -1650 1 1 {name=l139 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5260 -1650 3 0 {name=l140 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4510 -1640 2 1 {name=l159 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4530 -1650 1 1 {name=l160 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4570 -1650 3 0 {name=l161 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4160 -1640 2 1 {name=l162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -1650 1 1 {name=l163 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4220 -1650 3 0 {name=l164 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3830 -1640 2 1 {name=l231 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3850 -1650 1 1 {name=l232 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3890 -1650 3 0 {name=l233 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3500 -1640 2 1 {name=l234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3520 -1650 1 1 {name=l235 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3560 -1650 3 0 {name=l236 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3140 -1640 2 1 {name=l237 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3160 -1650 1 1 {name=l238 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3200 -1650 3 0 {name=l239 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2790 -1640 2 1 {name=l240 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2810 -1650 1 1 {name=l241 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2850 -1650 3 0 {name=l242 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2450 -1640 2 1 {name=l243 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2470 -1650 1 1 {name=l244 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2510 -1650 3 0 {name=l245 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2100 -1640 2 1 {name=l246 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2120 -1650 1 1 {name=l247 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2160 -1650 3 0 {name=l248 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1750 -1640 2 1 {name=l249 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 -1650 1 1 {name=l250 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1810 -1650 3 0 {name=l251 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -1640 2 1 {name=l252 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -1650 1 1 {name=l253 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -1650 3 0 {name=l254 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1070 -1640 2 1 {name=l255 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1090 -1650 1 1 {name=l256 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1130 -1650 3 0 {name=l257 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 750 -1640 2 1 {name=l258 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 770 -1650 1 1 {name=l259 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 810 -1650 3 0 {name=l260 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_drv.sym} 470 -1680 0 0 {name=x65}
C {adc_sar_wafflecap_8_8.sym} 890 -1560 0 0 {name=x66}
C {adc_sar_wafflecap_8_8.sym} 1220 -1560 0 0 {name=x67}
C {adc_sar_wafflecap_8_8.sym} 1570 -1560 0 0 {name=x68}
C {adc_sar_wafflecap_8_8.sym} 1920 -1560 0 0 {name=x69}
C {adc_sar_wafflecap_8_8.sym} 2270 -1560 0 0 {name=x70}
C {adc_sar_wafflecap_8_8.sym} 2610 -1560 0 0 {name=x71}
C {adc_sar_wafflecap_8_8.sym} 2960 -1560 0 0 {name=x72}
C {adc_sar_wafflecap_8_8.sym} 3320 -1560 0 0 {name=x73}
C {adc_sar_wafflecap_8_8.sym} 3650 -1560 0 0 {name=x74}
C {adc_sar_wafflecap_8_8.sym} 3980 -1560 0 0 {name=x75}
C {adc_sar_wafflecap_8_8.sym} 4330 -1560 0 0 {name=x76}
C {adc_sar_wafflecap_8_8.sym} 4680 -1560 0 0 {name=x77}
C {adc_sar_wafflecap_8_8.sym} 5020 -1560 0 0 {name=x78}
C {devices/lab_wire.sym} 750 -1720 3 0 {name=l261 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1070 -1720 3 0 {name=l262 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1400 -1720 3 0 {name=l263 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1750 -1720 3 0 {name=l264 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2100 -1720 3 0 {name=l265 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2450 -1720 3 0 {name=l266 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2790 -1720 3 0 {name=l267 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3140 -1720 3 0 {name=l268 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3500 -1720 3 0 {name=l269 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3830 -1720 3 0 {name=l270 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4160 -1720 3 0 {name=l271 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4510 -1720 3 0 {name=l272 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4860 -1720 3 0 {name=l273 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5200 -1720 3 0 {name=l274 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -1720 3 0 {name=l275 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -1960 2 1 {name=l277 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -1970 1 1 {name=l278 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5600 -1970 3 0 {name=l279 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4860 -1960 2 1 {name=l283 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4880 -1970 1 1 {name=l284 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4920 -1970 3 0 {name=l285 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5200 -1960 2 1 {name=l286 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5220 -1970 1 1 {name=l287 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5260 -1970 3 0 {name=l288 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4510 -1960 2 1 {name=l289 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4530 -1970 1 1 {name=l290 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4570 -1970 3 0 {name=l291 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4160 -1960 2 1 {name=l292 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -1970 1 1 {name=l293 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4220 -1970 3 0 {name=l294 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3830 -1960 2 1 {name=l295 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3850 -1970 1 1 {name=l296 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3890 -1970 3 0 {name=l297 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3500 -1960 2 1 {name=l298 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3520 -1970 1 1 {name=l299 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3560 -1970 3 0 {name=l300 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3140 -1960 2 1 {name=l301 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3160 -1970 1 1 {name=l302 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3200 -1970 3 0 {name=l303 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2790 -1960 2 1 {name=l304 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2810 -1970 1 1 {name=l305 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2850 -1970 3 0 {name=l306 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2450 -1960 2 1 {name=l307 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2470 -1970 1 1 {name=l308 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2510 -1970 3 0 {name=l309 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2100 -1960 2 1 {name=l310 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2120 -1970 1 1 {name=l311 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2160 -1970 3 0 {name=l312 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1750 -1960 2 1 {name=l313 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 -1970 1 1 {name=l314 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1810 -1970 3 0 {name=l315 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -1960 2 1 {name=l316 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -1970 1 1 {name=l317 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -1970 3 0 {name=l318 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1070 -1960 2 1 {name=l319 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1090 -1970 1 1 {name=l320 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1130 -1970 3 0 {name=l321 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 750 -1960 2 1 {name=l322 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 770 -1970 1 1 {name=l323 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 810 -1970 3 0 {name=l324 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 690 -1810 0 0 {name=l325 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 690 -1870 0 0 {name=l326 sig_type=std_logic lab=row_n[3]}
C {devices/lab_wire.sym} 690 -1850 0 0 {name=l327 sig_type=std_logic lab=rowon_n[3]}
C {devices/lab_wire.sym} 690 -1830 0 0 {name=l328 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 690 -2140 0 0 {name=l329 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 690 -2200 0 0 {name=l330 sig_type=std_logic lab=row_n[4]}
C {devices/lab_wire.sym} 690 -2180 0 0 {name=l331 sig_type=std_logic lab=rowon_n[4]}
C {devices/lab_wire.sym} 690 -2160 0 0 {name=l332 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 690 -1890 0 0 {name=l333 sig_type=std_logic lab=rowoff_n[3]}
C {devices/lab_wire.sym} 690 -2220 0 0 {name=l334 sig_type=std_logic lab=rowoff_n[4]}
C {adc_sar_wafflecap_drv.sym} 470 -2010 0 0 {name=x81}
C {adc_sar_wafflecap_8_8.sym} 890 -1890 0 0 {name=x82}
C {adc_sar_wafflecap_8_8.sym} 1220 -1890 0 0 {name=x83}
C {adc_sar_wafflecap_8_8.sym} 1570 -1890 0 0 {name=x84}
C {adc_sar_wafflecap_8_8.sym} 1920 -1890 0 0 {name=x85}
C {adc_sar_wafflecap_8_8.sym} 2270 -1890 0 0 {name=x86}
C {adc_sar_wafflecap_8_8.sym} 2610 -1890 0 0 {name=x87}
C {adc_sar_wafflecap_8_8.sym} 2960 -1890 0 0 {name=x88}
C {adc_sar_wafflecap_8_8.sym} 3320 -1890 0 0 {name=x89}
C {adc_sar_wafflecap_8_8.sym} 3650 -1890 0 0 {name=x90}
C {adc_sar_wafflecap_8_8.sym} 3980 -1890 0 0 {name=x91}
C {adc_sar_wafflecap_8_8.sym} 4330 -1890 0 0 {name=x92}
C {adc_sar_wafflecap_8_8.sym} 4680 -1890 0 0 {name=x93}
C {adc_sar_wafflecap_8_8.sym} 5020 -1890 0 0 {name=x94}
C {devices/lab_wire.sym} 750 -2050 3 0 {name=l335 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1070 -2050 3 0 {name=l336 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1400 -2050 3 0 {name=l337 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1750 -2050 3 0 {name=l338 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2100 -2050 3 0 {name=l339 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2450 -2050 3 0 {name=l340 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2790 -2050 3 0 {name=l341 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3140 -2050 3 0 {name=l342 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3500 -2050 3 0 {name=l343 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3830 -2050 3 0 {name=l344 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4160 -2050 3 0 {name=l345 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4510 -2050 3 0 {name=l346 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4860 -2050 3 0 {name=l347 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5200 -2050 3 0 {name=l348 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -2050 3 0 {name=l349 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -2290 2 1 {name=l351 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -2300 1 1 {name=l352 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5600 -2300 3 0 {name=l353 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4860 -2290 2 1 {name=l357 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4880 -2300 1 1 {name=l358 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4920 -2300 3 0 {name=l359 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5200 -2290 2 1 {name=l360 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5220 -2300 1 1 {name=l361 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5260 -2300 3 0 {name=l362 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4510 -2290 2 1 {name=l363 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4530 -2300 1 1 {name=l364 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4570 -2300 3 0 {name=l365 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4160 -2290 2 1 {name=l366 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -2300 1 1 {name=l367 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4220 -2300 3 0 {name=l368 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3830 -2290 2 1 {name=l369 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3850 -2300 1 1 {name=l370 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3890 -2300 3 0 {name=l371 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3500 -2290 2 1 {name=l372 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3520 -2300 1 1 {name=l373 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3560 -2300 3 0 {name=l374 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3140 -2290 2 1 {name=l375 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3160 -2300 1 1 {name=l376 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3200 -2300 3 0 {name=l377 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2790 -2290 2 1 {name=l378 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2810 -2300 1 1 {name=l379 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2850 -2300 3 0 {name=l380 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2450 -2290 2 1 {name=l381 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2470 -2300 1 1 {name=l382 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2510 -2300 3 0 {name=l383 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2100 -2290 2 1 {name=l384 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2120 -2300 1 1 {name=l385 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2160 -2300 3 0 {name=l386 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1750 -2290 2 1 {name=l387 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 -2300 1 1 {name=l388 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1810 -2300 3 0 {name=l389 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -2290 2 1 {name=l390 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -2300 1 1 {name=l391 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -2300 3 0 {name=l392 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1070 -2290 2 1 {name=l393 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1090 -2300 1 1 {name=l394 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1130 -2300 3 0 {name=l395 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 750 -2290 2 1 {name=l396 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 770 -2300 1 1 {name=l397 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 810 -2300 3 0 {name=l398 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_drv.sym} 470 -2360 0 0 {name=x97}
C {adc_sar_wafflecap_8_8.sym} 890 -2240 0 0 {name=x98}
C {adc_sar_wafflecap_8_8.sym} 1220 -2240 0 0 {name=x99}
C {adc_sar_wafflecap_8_8.sym} 1570 -2240 0 0 {name=x100}
C {adc_sar_wafflecap_8_8.sym} 1920 -2240 0 0 {name=x101}
C {adc_sar_wafflecap_8_8.sym} 2270 -2240 0 0 {name=x102}
C {adc_sar_wafflecap_8_8.sym} 2610 -2240 0 0 {name=x103}
C {adc_sar_wafflecap_8_8.sym} 2960 -2240 0 0 {name=x104}
C {adc_sar_wafflecap_8_8.sym} 3320 -2240 0 0 {name=x105}
C {adc_sar_wafflecap_8_8.sym} 3650 -2240 0 0 {name=x106}
C {adc_sar_wafflecap_8_8.sym} 3980 -2240 0 0 {name=x107}
C {adc_sar_wafflecap_8_8.sym} 4330 -2240 0 0 {name=x108}
C {adc_sar_wafflecap_8_8.sym} 4680 -2240 0 0 {name=x109}
C {adc_sar_wafflecap_8_8.sym} 5020 -2240 0 0 {name=x110}
C {devices/lab_wire.sym} 750 -2400 3 0 {name=l399 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1070 -2400 3 0 {name=l400 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1400 -2400 3 0 {name=l401 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1750 -2400 3 0 {name=l402 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2100 -2400 3 0 {name=l403 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2450 -2400 3 0 {name=l404 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2790 -2400 3 0 {name=l405 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3140 -2400 3 0 {name=l406 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3500 -2400 3 0 {name=l407 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3830 -2400 3 0 {name=l408 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4160 -2400 3 0 {name=l409 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4510 -2400 3 0 {name=l410 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4860 -2400 3 0 {name=l411 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5200 -2400 3 0 {name=l412 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -2400 3 0 {name=l413 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -2640 2 1 {name=l415 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -2650 1 1 {name=l416 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5600 -2650 3 0 {name=l417 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4860 -2640 2 1 {name=l421 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4880 -2650 1 1 {name=l422 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4920 -2650 3 0 {name=l423 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5200 -2640 2 1 {name=l424 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5220 -2650 1 1 {name=l425 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5260 -2650 3 0 {name=l426 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4510 -2640 2 1 {name=l427 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4530 -2650 1 1 {name=l428 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4570 -2650 3 0 {name=l429 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4160 -2640 2 1 {name=l430 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -2650 1 1 {name=l431 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4220 -2650 3 0 {name=l432 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3830 -2640 2 1 {name=l433 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3850 -2650 1 1 {name=l434 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3890 -2650 3 0 {name=l435 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3500 -2640 2 1 {name=l436 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3520 -2650 1 1 {name=l437 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3560 -2650 3 0 {name=l438 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3140 -2640 2 1 {name=l439 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3160 -2650 1 1 {name=l440 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3200 -2650 3 0 {name=l441 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2790 -2640 2 1 {name=l442 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2810 -2650 1 1 {name=l443 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2850 -2650 3 0 {name=l444 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2450 -2640 2 1 {name=l445 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2470 -2650 1 1 {name=l446 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2510 -2650 3 0 {name=l447 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2100 -2640 2 1 {name=l448 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2120 -2650 1 1 {name=l449 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2160 -2650 3 0 {name=l450 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1750 -2640 2 1 {name=l451 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 -2650 1 1 {name=l452 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1810 -2650 3 0 {name=l453 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -2640 2 1 {name=l454 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -2650 1 1 {name=l455 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -2650 3 0 {name=l456 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1070 -2640 2 1 {name=l457 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1090 -2650 1 1 {name=l458 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1130 -2650 3 0 {name=l459 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 750 -2640 2 1 {name=l460 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 770 -2650 1 1 {name=l461 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 810 -2650 3 0 {name=l462 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 690 -2490 0 0 {name=l463 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 690 -2550 0 0 {name=l464 sig_type=std_logic lab=row_n[5]}
C {devices/lab_wire.sym} 690 -2530 0 0 {name=l465 sig_type=std_logic lab=rowon_n[5]}
C {devices/lab_wire.sym} 690 -2510 0 0 {name=l466 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 690 -2820 0 0 {name=l467 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 690 -2880 0 0 {name=l468 sig_type=std_logic lab=row_n[6]}
C {devices/lab_wire.sym} 690 -2860 0 0 {name=l469 sig_type=std_logic lab=rowon_n[6]}
C {devices/lab_wire.sym} 690 -2840 0 0 {name=l470 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 690 -2570 0 0 {name=l471 sig_type=std_logic lab=rowoff_n[5]}
C {devices/lab_wire.sym} 690 -2900 0 0 {name=l472 sig_type=std_logic lab=rowoff_n[6]}
C {adc_sar_wafflecap_drv.sym} 470 -2690 0 0 {name=x113}
C {adc_sar_wafflecap_8_8.sym} 890 -2570 0 0 {name=x114}
C {adc_sar_wafflecap_8_8.sym} 1220 -2570 0 0 {name=x115}
C {adc_sar_wafflecap_8_8.sym} 1570 -2570 0 0 {name=x116}
C {adc_sar_wafflecap_8_8.sym} 1920 -2570 0 0 {name=x117}
C {adc_sar_wafflecap_8_8.sym} 2270 -2570 0 0 {name=x118}
C {adc_sar_wafflecap_8_8.sym} 2610 -2570 0 0 {name=x119}
C {adc_sar_wafflecap_8_8.sym} 2960 -2570 0 0 {name=x120}
C {adc_sar_wafflecap_8_8.sym} 3320 -2570 0 0 {name=x121}
C {adc_sar_wafflecap_8_8.sym} 3650 -2570 0 0 {name=x122}
C {adc_sar_wafflecap_8_8.sym} 3980 -2570 0 0 {name=x123}
C {adc_sar_wafflecap_8_8.sym} 4330 -2570 0 0 {name=x124}
C {adc_sar_wafflecap_8_8.sym} 4680 -2570 0 0 {name=x125}
C {adc_sar_wafflecap_8_8.sym} 5020 -2570 0 0 {name=x126}
C {devices/lab_wire.sym} 750 -2730 3 0 {name=l473 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1070 -2730 3 0 {name=l474 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1400 -2730 3 0 {name=l475 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1750 -2730 3 0 {name=l476 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2100 -2730 3 0 {name=l477 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2450 -2730 3 0 {name=l478 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2790 -2730 3 0 {name=l479 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3140 -2730 3 0 {name=l480 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3500 -2730 3 0 {name=l481 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3830 -2730 3 0 {name=l482 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4160 -2730 3 0 {name=l483 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4510 -2730 3 0 {name=l484 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4860 -2730 3 0 {name=l485 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5200 -2730 3 0 {name=l486 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -2730 3 0 {name=l487 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -2970 2 1 {name=l489 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -2980 1 1 {name=l490 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5600 -2980 3 0 {name=l491 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4860 -2970 2 1 {name=l495 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4880 -2980 1 1 {name=l496 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4920 -2980 3 0 {name=l497 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5200 -2970 2 1 {name=l498 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5220 -2980 1 1 {name=l499 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5260 -2980 3 0 {name=l500 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4510 -2970 2 1 {name=l501 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4530 -2980 1 1 {name=l502 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4570 -2980 3 0 {name=l503 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4160 -2970 2 1 {name=l504 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -2980 1 1 {name=l505 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4220 -2980 3 0 {name=l506 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3830 -2970 2 1 {name=l507 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3850 -2980 1 1 {name=l508 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3890 -2980 3 0 {name=l509 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3500 -2970 2 1 {name=l510 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3520 -2980 1 1 {name=l511 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3560 -2980 3 0 {name=l512 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3140 -2970 2 1 {name=l513 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3160 -2980 1 1 {name=l514 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3200 -2980 3 0 {name=l515 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2790 -2970 2 1 {name=l516 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2810 -2980 1 1 {name=l517 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2850 -2980 3 0 {name=l518 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2450 -2970 2 1 {name=l519 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2470 -2980 1 1 {name=l520 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2510 -2980 3 0 {name=l521 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2100 -2970 2 1 {name=l522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2120 -2980 1 1 {name=l523 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2160 -2980 3 0 {name=l524 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1750 -2970 2 1 {name=l525 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 -2980 1 1 {name=l526 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1810 -2980 3 0 {name=l527 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -2970 2 1 {name=l528 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -2980 1 1 {name=l529 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -2980 3 0 {name=l530 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1070 -2970 2 1 {name=l531 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1090 -2980 1 1 {name=l532 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1130 -2980 3 0 {name=l533 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 750 -2970 2 1 {name=l534 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 770 -2980 1 1 {name=l535 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 810 -2980 3 0 {name=l536 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_drv.sym} 470 -3010 0 0 {name=x129}
C {adc_sar_wafflecap_8_8.sym} 890 -2890 0 0 {name=x130}
C {adc_sar_wafflecap_8_8.sym} 1220 -2890 0 0 {name=x131}
C {adc_sar_wafflecap_8_8.sym} 1570 -2890 0 0 {name=x132}
C {adc_sar_wafflecap_8_8.sym} 1920 -2890 0 0 {name=x133}
C {adc_sar_wafflecap_8_8.sym} 2270 -2890 0 0 {name=x134}
C {adc_sar_wafflecap_8_8.sym} 2610 -2890 0 0 {name=x135}
C {adc_sar_wafflecap_8_8.sym} 2960 -2890 0 0 {name=x136}
C {adc_sar_wafflecap_8_8.sym} 3320 -2890 0 0 {name=x137}
C {adc_sar_wafflecap_8_8.sym} 3650 -2890 0 0 {name=x138}
C {adc_sar_wafflecap_8_8.sym} 3980 -2890 0 0 {name=x139}
C {adc_sar_wafflecap_8_8.sym} 4330 -2890 0 0 {name=x140}
C {adc_sar_wafflecap_8_8.sym} 4680 -2890 0 0 {name=x141}
C {adc_sar_wafflecap_8_8.sym} 5020 -2890 0 0 {name=x142}
C {devices/lab_wire.sym} 750 -3050 3 0 {name=l537 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1070 -3050 3 0 {name=l538 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1400 -3050 3 0 {name=l539 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1750 -3050 3 0 {name=l540 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2100 -3050 3 0 {name=l541 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2450 -3050 3 0 {name=l542 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2790 -3050 3 0 {name=l543 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3140 -3050 3 0 {name=l544 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3500 -3050 3 0 {name=l545 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3830 -3050 3 0 {name=l546 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4160 -3050 3 0 {name=l547 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4510 -3050 3 0 {name=l548 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4860 -3050 3 0 {name=l549 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5200 -3050 3 0 {name=l550 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -3050 3 0 {name=l551 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -3290 2 1 {name=l553 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -3300 1 1 {name=l554 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5600 -3300 3 0 {name=l555 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4860 -3290 2 1 {name=l559 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4880 -3300 1 1 {name=l560 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4920 -3300 3 0 {name=l561 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5200 -3290 2 1 {name=l562 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5220 -3300 1 1 {name=l563 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5260 -3300 3 0 {name=l564 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4510 -3290 2 1 {name=l565 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4530 -3300 1 1 {name=l566 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4570 -3300 3 0 {name=l567 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4160 -3290 2 1 {name=l568 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -3300 1 1 {name=l569 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4220 -3300 3 0 {name=l570 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3830 -3290 2 1 {name=l571 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3850 -3300 1 1 {name=l572 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3890 -3300 3 0 {name=l573 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3500 -3290 2 1 {name=l574 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3520 -3300 1 1 {name=l575 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3560 -3300 3 0 {name=l576 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3140 -3290 2 1 {name=l577 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3160 -3300 1 1 {name=l578 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3200 -3300 3 0 {name=l579 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2790 -3290 2 1 {name=l580 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2810 -3300 1 1 {name=l581 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2850 -3300 3 0 {name=l582 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2450 -3290 2 1 {name=l583 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2470 -3300 1 1 {name=l584 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2510 -3300 3 0 {name=l585 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2100 -3290 2 1 {name=l586 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2120 -3300 1 1 {name=l587 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2160 -3300 3 0 {name=l588 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1750 -3290 2 1 {name=l589 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 -3300 1 1 {name=l590 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1810 -3300 3 0 {name=l591 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -3290 2 1 {name=l592 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -3300 1 1 {name=l593 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -3300 3 0 {name=l594 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1070 -3290 2 1 {name=l595 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1090 -3300 1 1 {name=l596 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1130 -3300 3 0 {name=l597 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 750 -3290 2 1 {name=l598 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 770 -3300 1 1 {name=l599 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 810 -3300 3 0 {name=l600 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 690 -3140 0 0 {name=l601 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 690 -3200 0 0 {name=l602 sig_type=std_logic lab=row_n[7]}
C {devices/lab_wire.sym} 690 -3180 0 0 {name=l603 sig_type=std_logic lab=rowon_n[7]}
C {devices/lab_wire.sym} 690 -3160 0 0 {name=l604 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 690 -3470 0 0 {name=l605 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 690 -3530 0 0 {name=l606 sig_type=std_logic lab=row_n[8]}
C {devices/lab_wire.sym} 690 -3510 0 0 {name=l607 sig_type=std_logic lab=rowon_n[8]}
C {devices/lab_wire.sym} 690 -3490 0 0 {name=l608 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 690 -3220 0 0 {name=l609 sig_type=std_logic lab=rowoff_n[7]}
C {devices/lab_wire.sym} 690 -3550 0 0 {name=l610 sig_type=std_logic lab=rowoff_n[8]}
C {adc_sar_wafflecap_drv.sym} 470 -3340 0 0 {name=x145}
C {adc_sar_wafflecap_8_8.sym} 890 -3220 0 0 {name=x146}
C {adc_sar_wafflecap_8_8.sym} 1220 -3220 0 0 {name=x147}
C {adc_sar_wafflecap_8_8.sym} 1570 -3220 0 0 {name=x148}
C {adc_sar_wafflecap_8_8.sym} 1920 -3220 0 0 {name=x149}
C {adc_sar_wafflecap_8_8.sym} 2270 -3220 0 0 {name=x150}
C {adc_sar_wafflecap_8_8.sym} 2610 -3220 0 0 {name=x151}
C {adc_sar_wafflecap_8_8.sym} 2960 -3220 0 0 {name=x152}
C {adc_sar_wafflecap_8_8.sym} 3320 -3220 0 0 {name=x153}
C {adc_sar_wafflecap_8_8.sym} 3650 -3220 0 0 {name=x154}
C {adc_sar_wafflecap_8_8.sym} 3980 -3220 0 0 {name=x155}
C {adc_sar_wafflecap_8_8.sym} 4330 -3220 0 0 {name=x156}
C {adc_sar_wafflecap_8_8.sym} 4680 -3220 0 0 {name=x157}
C {adc_sar_wafflecap_8_8.sym} 5020 -3220 0 0 {name=x158}
C {devices/lab_wire.sym} 750 -3380 3 0 {name=l611 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1070 -3380 3 0 {name=l612 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1400 -3380 3 0 {name=l613 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1750 -3380 3 0 {name=l614 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2100 -3380 3 0 {name=l615 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2450 -3380 3 0 {name=l616 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2790 -3380 3 0 {name=l617 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3140 -3380 3 0 {name=l618 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3500 -3380 3 0 {name=l619 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3830 -3380 3 0 {name=l620 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4160 -3380 3 0 {name=l621 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4510 -3380 3 0 {name=l622 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4860 -3380 3 0 {name=l623 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5200 -3380 3 0 {name=l624 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -3380 3 0 {name=l625 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -3620 2 1 {name=l627 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -3630 1 1 {name=l628 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5600 -3630 3 0 {name=l629 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4860 -3620 2 1 {name=l633 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4880 -3630 1 1 {name=l634 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4920 -3630 3 0 {name=l635 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5200 -3620 2 1 {name=l636 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5220 -3630 1 1 {name=l637 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5260 -3630 3 0 {name=l638 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4510 -3620 2 1 {name=l639 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4530 -3630 1 1 {name=l640 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4570 -3630 3 0 {name=l641 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4160 -3620 2 1 {name=l642 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -3630 1 1 {name=l643 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4220 -3630 3 0 {name=l644 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3830 -3620 2 1 {name=l645 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3850 -3630 1 1 {name=l646 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3890 -3630 3 0 {name=l647 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3500 -3620 2 1 {name=l648 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3520 -3630 1 1 {name=l649 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3560 -3630 3 0 {name=l650 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3140 -3620 2 1 {name=l651 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3160 -3630 1 1 {name=l652 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3200 -3630 3 0 {name=l653 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2790 -3620 2 1 {name=l654 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2810 -3630 1 1 {name=l655 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2850 -3630 3 0 {name=l656 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2450 -3620 2 1 {name=l657 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2470 -3630 1 1 {name=l658 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2510 -3630 3 0 {name=l659 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2100 -3620 2 1 {name=l660 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2120 -3630 1 1 {name=l661 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2160 -3630 3 0 {name=l662 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1750 -3620 2 1 {name=l663 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 -3630 1 1 {name=l664 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1810 -3630 3 0 {name=l665 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -3620 2 1 {name=l666 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -3630 1 1 {name=l667 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -3630 3 0 {name=l668 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1070 -3620 2 1 {name=l669 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1090 -3630 1 1 {name=l670 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1130 -3630 3 0 {name=l671 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 750 -3620 2 1 {name=l672 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 770 -3630 1 1 {name=l673 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 810 -3630 3 0 {name=l674 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_drv.sym} 470 -3650 0 0 {name=x161}
C {adc_sar_wafflecap_8_8.sym} 890 -3530 0 0 {name=x162}
C {adc_sar_wafflecap_8_8.sym} 1220 -3530 0 0 {name=x163}
C {adc_sar_wafflecap_8_8.sym} 1570 -3530 0 0 {name=x164}
C {adc_sar_wafflecap_8_8.sym} 1920 -3530 0 0 {name=x165}
C {adc_sar_wafflecap_8_8.sym} 2270 -3530 0 0 {name=x166}
C {adc_sar_wafflecap_8_8.sym} 2610 -3530 0 0 {name=x167}
C {adc_sar_wafflecap_8_8.sym} 2960 -3530 0 0 {name=x168}
C {adc_sar_wafflecap_8_8.sym} 3320 -3530 0 0 {name=x169}
C {adc_sar_wafflecap_8_8.sym} 3650 -3530 0 0 {name=x170}
C {adc_sar_wafflecap_8_8.sym} 3980 -3530 0 0 {name=x171}
C {adc_sar_wafflecap_8_8.sym} 4330 -3530 0 0 {name=x172}
C {adc_sar_wafflecap_8_8.sym} 4680 -3530 0 0 {name=x173}
C {adc_sar_wafflecap_8_8.sym} 5020 -3530 0 0 {name=x174}
C {devices/lab_wire.sym} 750 -3690 3 0 {name=l675 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1070 -3690 3 0 {name=l676 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1400 -3690 3 0 {name=l677 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1750 -3690 3 0 {name=l678 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2100 -3690 3 0 {name=l679 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2450 -3690 3 0 {name=l680 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2790 -3690 3 0 {name=l681 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3140 -3690 3 0 {name=l682 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3500 -3690 3 0 {name=l683 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3830 -3690 3 0 {name=l684 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4160 -3690 3 0 {name=l685 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4510 -3690 3 0 {name=l686 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4860 -3690 3 0 {name=l687 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5200 -3690 3 0 {name=l688 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -3690 3 0 {name=l689 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -3930 2 1 {name=l691 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -3940 1 1 {name=l692 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5600 -3940 3 0 {name=l693 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4860 -3930 2 1 {name=l697 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4880 -3940 1 1 {name=l698 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4920 -3940 3 0 {name=l699 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5200 -3930 2 1 {name=l700 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5220 -3940 1 1 {name=l701 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5260 -3940 3 0 {name=l702 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4510 -3930 2 1 {name=l703 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4530 -3940 1 1 {name=l704 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4570 -3940 3 0 {name=l705 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4160 -3930 2 1 {name=l706 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -3940 1 1 {name=l707 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4220 -3940 3 0 {name=l708 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3830 -3930 2 1 {name=l709 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3850 -3940 1 1 {name=l710 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3890 -3940 3 0 {name=l711 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3500 -3930 2 1 {name=l712 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3520 -3940 1 1 {name=l713 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3560 -3940 3 0 {name=l714 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3140 -3930 2 1 {name=l715 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3160 -3940 1 1 {name=l716 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3200 -3940 3 0 {name=l717 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2790 -3930 2 1 {name=l718 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2810 -3940 1 1 {name=l719 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2850 -3940 3 0 {name=l720 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2450 -3930 2 1 {name=l721 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2470 -3940 1 1 {name=l722 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2510 -3940 3 0 {name=l723 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2100 -3930 2 1 {name=l724 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2120 -3940 1 1 {name=l725 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2160 -3940 3 0 {name=l726 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1750 -3930 2 1 {name=l727 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 -3940 1 1 {name=l728 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1810 -3940 3 0 {name=l729 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -3930 2 1 {name=l730 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -3940 1 1 {name=l731 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -3940 3 0 {name=l732 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1070 -3930 2 1 {name=l733 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1090 -3940 1 1 {name=l734 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1130 -3940 3 0 {name=l735 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 750 -3930 2 1 {name=l736 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 770 -3940 1 1 {name=l737 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 810 -3940 3 0 {name=l738 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 690 -3780 0 0 {name=l739 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 690 -3840 0 0 {name=l740 sig_type=std_logic lab=row_n[9]}
C {devices/lab_wire.sym} 690 -3820 0 0 {name=l741 sig_type=std_logic lab=rowon_n[9]}
C {devices/lab_wire.sym} 690 -3800 0 0 {name=l742 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 690 -4110 0 0 {name=l743 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 690 -4170 0 0 {name=l744 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 690 -4150 0 0 {name=l745 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 690 -4130 0 0 {name=l746 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 690 -3860 0 0 {name=l747 sig_type=std_logic lab=rowoff_n[9]}
C {devices/lab_wire.sym} 690 -4190 0 0 {name=l748 sig_type=std_logic lab=VSS}
C {adc_sar_wafflecap_drv.sym} 470 -3980 0 0 {name=x177}
C {devices/lab_wire.sym} 750 -4020 3 0 {name=l749 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1070 -4020 3 0 {name=l750 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1400 -4020 3 0 {name=l751 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1750 -4020 3 0 {name=l752 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2100 -4020 3 0 {name=l753 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2450 -4020 3 0 {name=l754 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2790 -4020 3 0 {name=l755 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3140 -4020 3 0 {name=l756 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3500 -4020 3 0 {name=l757 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3830 -4020 3 0 {name=l758 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4160 -4020 3 0 {name=l759 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4510 -4020 3 0 {name=l760 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4860 -4020 3 0 {name=l761 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5200 -4020 3 0 {name=l762 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -4020 3 0 {name=l763 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5540 -4260 2 1 {name=l765 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5560 -4270 1 1 {name=l766 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5600 -4270 3 0 {name=l767 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4860 -4260 2 1 {name=l771 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4880 -4270 1 1 {name=l772 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4920 -4270 3 0 {name=l773 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5200 -4260 2 1 {name=l774 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5220 -4270 1 1 {name=l775 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5260 -4270 3 0 {name=l776 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4510 -4260 2 1 {name=l777 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4530 -4270 1 1 {name=l778 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4570 -4270 3 0 {name=l779 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4160 -4260 2 1 {name=l780 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -4270 1 1 {name=l781 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4220 -4270 3 0 {name=l782 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3830 -4260 2 1 {name=l783 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3850 -4270 1 1 {name=l784 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3890 -4270 3 0 {name=l785 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3500 -4260 2 1 {name=l786 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3520 -4270 1 1 {name=l787 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3560 -4270 3 0 {name=l788 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3140 -4260 2 1 {name=l789 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3160 -4270 1 1 {name=l790 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3200 -4270 3 0 {name=l791 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2790 -4260 2 1 {name=l792 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2810 -4270 1 1 {name=l793 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2850 -4270 3 0 {name=l794 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2450 -4260 2 1 {name=l795 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2470 -4270 1 1 {name=l796 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2510 -4270 3 0 {name=l797 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2100 -4260 2 1 {name=l798 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2120 -4270 1 1 {name=l799 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2160 -4270 3 0 {name=l800 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1750 -4260 2 1 {name=l801 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 -4270 1 1 {name=l802 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1810 -4270 3 0 {name=l803 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1400 -4260 2 1 {name=l804 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -4270 1 1 {name=l805 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1460 -4270 3 0 {name=l806 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1070 -4260 2 1 {name=l807 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1090 -4270 1 1 {name=l808 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1130 -4270 3 0 {name=l809 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 750 -4260 2 1 {name=l810 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 770 -4270 1 1 {name=l811 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 810 -4270 3 0 {name=l812 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_dummy.sym} 4960 -3940 0 0 {name=x180}
C {adc_sar_wafflecap_dummy.sym} 4620 -3940 0 0 {name=x181}
C {adc_sar_wafflecap_dummy.sym} 4270 -3940 0 0 {name=x182}
C {adc_sar_wafflecap_dummy.sym} 3920 -3940 0 0 {name=x183}
C {adc_sar_wafflecap_dummy.sym} 3590 -3940 0 0 {name=x184}
C {adc_sar_wafflecap_dummy.sym} 3260 -3940 0 0 {name=x185}
C {adc_sar_wafflecap_dummy.sym} 2900 -3940 0 0 {name=x186}
C {adc_sar_wafflecap_dummy.sym} 2550 -3940 0 0 {name=x187}
C {adc_sar_wafflecap_dummy.sym} 2210 -3940 0 0 {name=x188}
C {adc_sar_wafflecap_dummy.sym} 1860 -3940 0 0 {name=x189}
C {adc_sar_wafflecap_dummy.sym} 1510 -3940 0 0 {name=x190}
C {adc_sar_wafflecap_dummy.sym} 1160 -3940 0 0 {name=x191}
C {adc_sar_wafflecap_dummy.sym} 830 -3940 0 0 {name=x192}
C {devices/iopin.sym} 7060 -1110 1 1 {name=p1 lab=VDD}
C {devices/iopin.sym} 7070 -730 3 1 {name=p2 lab=VSS}
C {devices/iopin.sym} 7080 -1110 1 1 {name=p9 lab=vcm}
C {devices/ipin.sym} 7020 -1030 0 0 {name=p3 lab=sample}
C {devices/ipin.sym} 7020 -1010 0 0 {name=p4 lab=sample_n}
C {devices/ipin.sym} 7020 -980 0 0 {name=p5 lab=row_n[0:9]}
C {devices/ipin.sym} 7020 -960 0 0 {name=p6 lab=rowon_n[0:9]}
C {devices/ipin.sym} 7020 -920 0 0 {name=p7 lab=col_n[0:12]}
C {devices/ipin.sym} 7020 -880 0 0 {name=p10 lab=en_bit_n[0:2]}
C {devices/ipin.sym} 7020 -850 0 0 {name=p8 lab=en_C0_n}
C {devices/ipin.sym} 7020 -810 0 0 {name=p11 lab=sw}
C {devices/ipin.sym} 7020 -790 0 0 {name=p12 lab=sw_n}
C {devices/ipin.sym} 7020 -830 0 0 {name=p13 lab=analog_in}
C {devices/iopin.sym} 7120 -1070 0 0 {name=p14 lab=ctop}
C {devices/ipin.sym} 7020 -900 0 0 {name=p15 lab=col[0:12]}
C {devices/ipin.sym} 7020 -940 0 0 {name=p16 lab=rowoff_n[0:9]}
C {adc_sar_wafflecap_gate.sym} 4860 -420 0 0 {name=x14}
C {adc_sar_wafflecap_dummy.sym} 5300 -370 0 0 {name=x15}
C {adc_sar_wafflecap_dummy.sym} 5300 -990 0 0 {name=x16}
C {adc_sar_wafflecap_dummy.sym} 5300 -1320 0 0 {name=x32}
C {adc_sar_wafflecap_dummy.sym} 5300 -1640 0 0 {name=x47}
C {adc_sar_wafflecap_dummy.sym} 5300 -1970 0 0 {name=x48}
C {adc_sar_wafflecap_dummy.sym} 5300 -2320 0 0 {name=x63}
C {adc_sar_wafflecap_dummy.sym} 5300 -2650 0 0 {name=x64}
C {adc_sar_wafflecap_dummy.sym} 5300 -2970 0 0 {name=x79}
C {adc_sar_wafflecap_dummy.sym} 5300 -3300 0 0 {name=x80}
C {adc_sar_wafflecap_dummy.sym} 5300 -3610 0 0 {name=x95}
C {adc_sar_wafflecap_dummy.sym} 5300 -3940 0 0 {name=x96}
